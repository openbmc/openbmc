OBMC_IMAGE_EXTRA_INSTALL_append = "lrzsz sharutils lsof powerctrl"

