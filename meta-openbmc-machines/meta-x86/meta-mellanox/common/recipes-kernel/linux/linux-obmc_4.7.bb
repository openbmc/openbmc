KBRANCH ?= "dev-4.7"
LINUX_VERSION ?= "4.7.0"
SRCREV = "${AUTOREV}"

require linux-obmc-mlx.inc
