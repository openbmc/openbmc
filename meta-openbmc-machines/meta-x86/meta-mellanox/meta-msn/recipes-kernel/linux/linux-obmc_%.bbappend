FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://msn.cfg"