FILESEXTRAPATHS_prepend := "${THISDIR}/linux-zobmc:"
