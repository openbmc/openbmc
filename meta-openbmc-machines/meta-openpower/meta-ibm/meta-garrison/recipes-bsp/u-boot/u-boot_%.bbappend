FILESEXTRAPATHS_prepend_garrison := "${THISDIR}/${PN}:"
SRC_URI_append_garrison = " file://0001-Remove-CONFIG_FTGMAC100_EGIGA-for-ast-g4-phy.patch"
