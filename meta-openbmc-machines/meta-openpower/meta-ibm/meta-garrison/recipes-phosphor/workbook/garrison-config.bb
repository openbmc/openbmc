SUMMARY = "Garrison board wiring"
DESCRIPTION = "Board wiring information for the Garrison system."
PR = "r1"

inherit config-in-skeleton
