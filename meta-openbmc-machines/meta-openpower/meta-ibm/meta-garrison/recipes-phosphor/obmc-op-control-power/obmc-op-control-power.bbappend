FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"
SRC_URI += "file://Garrison-power-control-pcie-reset.patch"
