SRC_URI += "file://skeleton-0001-Temporarily-disable-watchdog-support.patch \
            file://skeleton-0001-Quick-fix-to-ensure-we-run-mbx-workaround-on-reboots.patch"

