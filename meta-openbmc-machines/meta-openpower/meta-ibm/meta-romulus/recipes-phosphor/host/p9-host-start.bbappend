RDEPENDS_${PN} += 'avsbus-control'
RDEPENDS_${PN} += 'vrm-control'
RDEPENDS_${PN} += 'vddr-control'
