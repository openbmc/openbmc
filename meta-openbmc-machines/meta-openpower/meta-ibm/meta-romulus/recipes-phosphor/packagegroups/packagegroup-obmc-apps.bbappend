RDEPENDS_${PN}-inventory += " openpower-occ-control phosphor-cooling-type"
