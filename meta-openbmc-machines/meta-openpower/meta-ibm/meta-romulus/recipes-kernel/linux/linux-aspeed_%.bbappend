FILESEXTRAPATHS_prepend_romulus := "${THISDIR}/${PN}:"
SRC_URI += "file://romulus.cfg"
