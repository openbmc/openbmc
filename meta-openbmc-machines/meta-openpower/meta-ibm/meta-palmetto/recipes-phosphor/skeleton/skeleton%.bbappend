RDEPENDS_skeleton_remove += "obmc-control-fan"
RDEPENDS_skeleton_remove += "obmc-button-reset"
