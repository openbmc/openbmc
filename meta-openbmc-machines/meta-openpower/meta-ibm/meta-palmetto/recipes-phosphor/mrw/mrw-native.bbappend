FILESEXTRAPATHS_prepend := "${THISDIR}/mrw-native:"
SRC_URI += "file://palmetto.xml.patch.xml"
