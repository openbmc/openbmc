SUMMARY = "Palmetto board wiring"
DESCRIPTION = "Board wiring information for the Palmetto system."
PR = "r1"

inherit config-in-skeleton
