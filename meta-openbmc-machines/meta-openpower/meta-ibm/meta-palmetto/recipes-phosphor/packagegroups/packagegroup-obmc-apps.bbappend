RDEPENDS_${PN}-inventory += "openpower-occ-control"
