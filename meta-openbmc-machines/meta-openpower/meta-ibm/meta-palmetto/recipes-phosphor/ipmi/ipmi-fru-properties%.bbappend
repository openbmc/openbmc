FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://extra-properties.yaml"

