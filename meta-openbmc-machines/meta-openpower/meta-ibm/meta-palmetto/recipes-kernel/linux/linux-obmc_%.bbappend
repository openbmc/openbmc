FILESEXTRAPATHS_prepend := "${THISDIR}/linux-obmc:"
SRC_URI += "file://palmetto.cfg"
SRC_URI += "file://occ_hwmon.patch"
