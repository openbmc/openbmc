FILESEXTRAPATHS_prepend_palmetto := "${THISDIR}/${PN}:"
SRC_URI += "file://palmetto.cfg"
