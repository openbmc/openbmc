STANDBY_OBJECTS = " \
        /org/openbmc/sensors \
        /org/openbmc/control/chassis0 \
        /org/openbmc/control/power0 \
        /org/openbmc/control/led/identify \
        /org/openbmc/control/host0 \
        /org/openbmc/control/flash/bios \
        "
