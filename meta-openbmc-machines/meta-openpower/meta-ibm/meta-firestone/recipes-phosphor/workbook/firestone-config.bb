SUMMARY = "Firestone board wiring"
DESCRIPTION = "Board wiring information for the Firestone system."
PR = "r1"

inherit config-in-skeleton
