FILESEXTRAPATHS_prepend_firestone := "${THISDIR}/${PN}:"
