PHOSPHOR_INVENTORY_MANAGER_CONFIGS += "inventory-cleanup-native"
