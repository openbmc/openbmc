FILESEXTRAPATHS_prepend := "${THISDIR}/phosphor-fan-monitor-config:"
