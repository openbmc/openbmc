FILESEXTRAPATHS_prepend := "${THISDIR}/phosphor-fan-control-zone-conditions-config:"
