FILESEXTRAPATHS_prepend := "${THISDIR}/phosphor-fan-control-events-config:"
