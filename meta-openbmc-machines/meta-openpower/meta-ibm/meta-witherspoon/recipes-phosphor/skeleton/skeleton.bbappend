FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Set-witherspoon-power-pin-and-pgood-nets.patch"
