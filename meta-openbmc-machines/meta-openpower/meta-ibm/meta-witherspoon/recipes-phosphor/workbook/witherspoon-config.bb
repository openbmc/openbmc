SUMMARY = "Witherspoon board wiring"
DESCRIPTION = "Board wiring information for the Witherspoon OpenPOWER system."
HOMEPAGE = "http://github.com/openbmc/skeleton"
PR = "r1"

SRCREV = "5774d44aa3dca936b6ddc118e2b3b0ea8e1c5f26"
inherit config-in-skeleton
inherit obmc-phosphor-license
