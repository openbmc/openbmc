OBMC_IMAGE_EXTRA_INSTALL_append = " vcs-pre-post"
