FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Enable-watchdog-and-set-watchdog-device-to-watchdog1.patch"
