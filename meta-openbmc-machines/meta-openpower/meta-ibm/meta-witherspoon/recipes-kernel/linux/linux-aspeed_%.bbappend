FILESEXTRAPATHS_prepend_witherspoon := "${THISDIR}/${PN}:"
SRC_URI += "file://witherspoon.cfg"
