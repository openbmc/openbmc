FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Witherspoon-OpenBMC-configuration.patch"
