IMAGE_FEATURES_remove = "obmc-fan-control"
OBMC_IMAGE_EXTRA_INSTALL_remove = "max31785-msl phosphor-msl-verify"
