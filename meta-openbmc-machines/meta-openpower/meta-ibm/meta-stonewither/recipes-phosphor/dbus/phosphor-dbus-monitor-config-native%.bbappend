PHOSPHOR_DBUS_MONITOR_CONFIGS_remove += \
    " \
    witherspoon-fan-policy-native \
    witherspoon-power-supply-policy-native \
    "
