PACKAGES_remove += "${PN}-fan-control"
