OBMC_IMAGE_EXTRA_INSTALL_append = " mboxd"
OBMC_IMAGE_EXTRA_INSTALL_append = " set-vio"
