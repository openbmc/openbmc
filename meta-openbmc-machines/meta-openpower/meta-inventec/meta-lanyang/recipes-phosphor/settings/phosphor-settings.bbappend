FILESEXTRAPATHS_append_lanyang := ":${THISDIR}/${PN}"
SRC_URI_append_lanyang = " file://powerpolicy-default-ALWAYS_POWER_ON.override.yml"
