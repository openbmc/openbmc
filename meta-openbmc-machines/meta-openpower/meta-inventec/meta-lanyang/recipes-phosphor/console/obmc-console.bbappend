FILESEXTRAPATHS_prepend_lanyang := "${THISDIR}/${PN}:"
