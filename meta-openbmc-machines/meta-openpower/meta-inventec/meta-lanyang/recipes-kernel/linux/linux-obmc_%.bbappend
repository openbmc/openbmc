FILESEXTRAPATHS_prepend_lanyang := "${THISDIR}/${PN}:"
SRC_URI_append_lanyang = " file://lanyang.cfg"
