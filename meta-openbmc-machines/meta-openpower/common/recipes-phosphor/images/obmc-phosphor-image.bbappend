OBMC_IMAGE_EXTRA_INSTALL_append = " inventory-upload openpower-vpd-parser"
