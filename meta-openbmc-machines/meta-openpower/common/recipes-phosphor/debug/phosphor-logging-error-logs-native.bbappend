DEPENDS += "openpower-debug-collector-error-native"
