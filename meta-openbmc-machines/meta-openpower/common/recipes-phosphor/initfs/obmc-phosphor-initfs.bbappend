RDEPENDS_${PN} += "cf-fsi-firmware"
