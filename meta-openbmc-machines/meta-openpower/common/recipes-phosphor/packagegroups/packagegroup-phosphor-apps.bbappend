RDEPENDS_${PN}-extrasdev += "obmc-pydevtools"
