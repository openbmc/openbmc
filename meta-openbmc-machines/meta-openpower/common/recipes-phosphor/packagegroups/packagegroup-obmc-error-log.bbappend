DEPENDS += "virtual/openpower-debug-collector-error-yaml"
