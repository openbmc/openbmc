OBMC_IPMI_SENSORS_PROVIDERS_append = " ${@cf_enabled(d, 'obmc-openpower', 'openpower-ipmi-oem-sensor-inventory-mrw-native')}"
