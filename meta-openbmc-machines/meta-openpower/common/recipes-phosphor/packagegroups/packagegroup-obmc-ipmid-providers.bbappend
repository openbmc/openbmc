OBMC_IPMID_PROVIDERS_append=" host-ipmid-oem"
