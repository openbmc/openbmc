RDEPENDS_${PN}-providers += " \
        obmc-hwmon \
        obmc-mgr-sensor \
        "
