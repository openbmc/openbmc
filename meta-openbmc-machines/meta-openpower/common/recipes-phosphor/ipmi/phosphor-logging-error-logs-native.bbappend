DEPENDS_append = " ${@cf_enabled(d, 'obmc-openpower', 'openpower-ipmi-oem-error-native')}"
