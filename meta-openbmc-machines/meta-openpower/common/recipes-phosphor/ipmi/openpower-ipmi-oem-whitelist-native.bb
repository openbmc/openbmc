SUMMARY = "Whitelisted OpenBMC IPMI OEM commands"
DESCRIPTION = "Whitelisted OpenBMC IPMI OEM commands for OpenPOWER based systems"

inherit obmc-phosphor-license
inherit native
inherit phosphor-ipmi-host-whitelist