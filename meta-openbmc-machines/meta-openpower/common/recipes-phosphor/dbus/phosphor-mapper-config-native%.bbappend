PHOSPHOR_MAPPER_CONFIGS_append = " ${@cf_enabled(d, 'obmc-openpower', 'openpower-dbus-interfaces-mapper-config-native')}"
