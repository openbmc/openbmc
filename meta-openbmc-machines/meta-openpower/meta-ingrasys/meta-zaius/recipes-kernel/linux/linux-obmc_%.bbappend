FILESEXTRAPATHS_prepend_zaius := "${THISDIR}/${PN}:"
SRC_URI_append_zaius = " file://zaius.cfg"
SRC_URI_append_zaius = " file://0001-drivers-fsi-Add-more-time-between-clocking-and-data-.patch
