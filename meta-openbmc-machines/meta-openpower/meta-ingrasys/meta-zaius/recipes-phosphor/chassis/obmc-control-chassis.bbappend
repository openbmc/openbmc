SRC_URI += "file://skeleton-0001-Temporarily-disable-watchdog-support.patch"
