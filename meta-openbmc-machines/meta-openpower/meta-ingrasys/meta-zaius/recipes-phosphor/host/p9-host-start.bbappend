RDEPENDS_${PN} += 'refclock-fixup'
