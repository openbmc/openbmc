SUMMARY = "BarreleyeG2 board wiring"
DESCRIPTION = "Board wiring information for the BarreleyeG2 OpenPOWER system."
PR = "r1"

inherit config-in-skeleton
