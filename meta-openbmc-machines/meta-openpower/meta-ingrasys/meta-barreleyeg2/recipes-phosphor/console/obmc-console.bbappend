FILESEXTRAPATHS_prepend_barreleyeg2 := "${THISDIR}/${PN}:"
