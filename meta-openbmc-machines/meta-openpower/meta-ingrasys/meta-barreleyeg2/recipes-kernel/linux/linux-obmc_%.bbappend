FILESEXTRAPATHS_prepend_barreleyeg2 := "${THISDIR}/${PN}:"
SRC_URI_append_barreleyeg2 = " file://barreleyeg2.cfg"
