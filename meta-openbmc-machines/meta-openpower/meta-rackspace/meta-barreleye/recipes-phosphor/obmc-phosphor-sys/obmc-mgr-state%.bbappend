STANDBY_OBJECTS = " \
        /org/openbmc/sensors \
        /org/openbmc/control/power0 \
        /org/openbmc/control/host0 \
        /org/openbmc/control/flash/bios \
        /org/openbmc/sensors/speed/fan5 \
        /org/openbmc/inventory/system/chassis/io_board \
        /org/openbmc/control/fans \
        /org/openbmc/control/chassis0 \
        "
