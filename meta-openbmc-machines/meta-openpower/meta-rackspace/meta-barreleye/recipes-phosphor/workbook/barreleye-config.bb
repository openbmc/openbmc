SUMMARY = "Barreleye board wiring"
DESCRIPTION = "Board wiring information for the Barreleye system."
HOMEPAGE = "http://github.com/openbmc/skeleton"
PR = "r1"

SRCREV = "6019000c3cc52d33d85906c93ffd1b8614b65c59"
inherit config-in-skeleton
inherit obmc-phosphor-license
