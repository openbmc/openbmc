FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI += "file://u-boot-barreleye.patch"
