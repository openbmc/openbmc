vpdlayout_datadir="${datadir}/openpower-fru-vpd/vpdlayout"
