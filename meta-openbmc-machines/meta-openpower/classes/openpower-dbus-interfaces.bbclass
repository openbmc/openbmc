op_yaml_dir="${datadir}/openpower-dbus-interfaces/yaml"
op_error_yaml_dir="${datadir}/error/yaml"
