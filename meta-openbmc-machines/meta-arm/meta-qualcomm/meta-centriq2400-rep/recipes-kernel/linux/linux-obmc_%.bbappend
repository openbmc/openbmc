FILESEXTRAPATHS_prepend_centriq2400-rep := "${THISDIR}/${PN}:"
SRC_URI += "file://centriq2400-rep.cfg"
