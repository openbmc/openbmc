SUMMARY = "A decorator for caching properties in classes."
HOMEPAGE = "https://github.com/pydanny/cached-property"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=db7ff60c4e14f58534201242803d8abc"

inherit pypi setuptools3

SRC_URI[md5sum] = "4a6039f7418007275505e355359396a8"
SRC_URI[sha256sum] = "458e78b1c7286ece887d92c9bee829da85717994c5e3ddd253a40467f488bc81"
