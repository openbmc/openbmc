inherit setuptools3
require python-docopt.inc
