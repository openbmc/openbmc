SUMMARY = "Python library to use the pseudo-tty of a docker container"
HOMEPAGE = "https://github.com/d11wtq/dockerpty"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=afaf767baa20ac524dc12f1071ca493a"

inherit pypi setuptools3

SRC_URI[md5sum] = "028bacb34536f3ee6a2ccd668c27e8e4"
SRC_URI[sha256sum] = "69a9d69d573a0daa31bcd1c0774eeed5c15c295fe719c61aca550ed1393156ce"
