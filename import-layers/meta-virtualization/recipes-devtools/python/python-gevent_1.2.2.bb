require python-gevent.inc
inherit setuptools

RDEPENDS_${PN} += "${PYTHON_PN}-re"
