require go-native.inc
require go-${PV}.inc
