OS_RELEASE_FIELDS += "CPE_NAME"

CPE_NAME="cpe:/o:openembedded:nodistro:0"

