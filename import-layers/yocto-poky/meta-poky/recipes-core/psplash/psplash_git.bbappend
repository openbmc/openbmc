FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"

