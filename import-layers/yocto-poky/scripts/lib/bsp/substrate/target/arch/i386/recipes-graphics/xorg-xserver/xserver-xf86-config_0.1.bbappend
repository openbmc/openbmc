# yocto-bsp-filename {{ if xserver == "y": }} this
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
