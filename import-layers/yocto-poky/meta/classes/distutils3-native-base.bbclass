PYTHON_BASEVERSION = "3.5"
PYTHON_ABI = "m"

inherit distutils-native-base
