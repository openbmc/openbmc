require u-boot-common_${PV}.inc
require u-boot.inc

DEPENDS += "bc-native dtc-native"
