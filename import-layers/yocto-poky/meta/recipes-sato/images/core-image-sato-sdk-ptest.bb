require core-image-sato-sdk.bb

DESCRIPTION += "Also includes ptest packages."

IMAGE_FEATURES += "ptest-pkgs"

