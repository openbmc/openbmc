require cups.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6c5a350596fba02754bd96eb6df3afd0"

SRC_URI[md5sum] = "9f9bf6e3b9c20a3519b4dc409666d6e7"
SRC_URI[sha256sum] = "4b14fd833180ac529ebebea766a09094c2568bf8426e219cb3a1715304ef728d"
