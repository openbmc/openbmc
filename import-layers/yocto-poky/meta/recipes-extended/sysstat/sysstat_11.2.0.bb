require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

SRC_URI += "file://0001-Include-needed-headers-explicitly.patch"

SRC_URI[md5sum] = "e8b615775ad98780e3f0675b91eddb19"
SRC_URI[sha256sum] = "9806b9a662568796d3fb93ecd01ecea10d815e668337a646494953bff4bc4155"
