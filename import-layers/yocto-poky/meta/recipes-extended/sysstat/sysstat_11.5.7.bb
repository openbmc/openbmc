require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a23a74b3f4caf9616230789d94217acb"

SRC_URI += "file://0001-Include-needed-headers-explicitly.patch"

SRC_URI[md5sum] = "8f4a5d0de29f1056153e25e7a9c518d2"
SRC_URI[sha256sum] = "4a38efaa0ca85ee5484d046bd427012979264fef17f07fd7855860e592819482"
