require augeas.inc

SRC_URI[md5sum] = "a2536a9c3d744dc09d234228fe4b0c93"
SRC_URI[sha256sum] = "659fae7ac229029e60a869a3b88c616cfd51cf2fba286cdfe3af3a052cb35b30"
