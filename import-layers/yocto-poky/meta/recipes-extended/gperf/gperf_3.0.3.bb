require gperf.inc

LICENSE  = "GPLv2+"
LIC_FILES_CHKSUM = "file://COPYING;md5=a5f84abb0070adf8a0925d7d534b6e0a \
                    file://src/main.cc;beginline=8;endline=19;md5=72a3034a19e72f08ee48ef8244a121fd"

PR = "r1"

SRC_URI[md5sum] = "cc20e58975a38075440423c8fb85fd00"
SRC_URI[sha256sum] = "63287527c8d9e27e801cf0804436f3494bd569db05d49dcdd2a942ae72fa9055"
