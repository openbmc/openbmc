require gstreamer1.0-rtsp-server.inc

SRC_URI[md5sum] = "ad70a9735f58da21d0f5cedf48ccadd3"
SRC_URI[sha256sum] = "7660112ebd59838f1054796b38109dcbe32f0a040e3a252a68a81055aeaa56a9"

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"
