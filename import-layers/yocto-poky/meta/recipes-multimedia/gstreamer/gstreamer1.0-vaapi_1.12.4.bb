require gstreamer1.0-vaapi.inc
SRC_URI[md5sum] = "2149982cdb348139bca946bb63766f4c"
SRC_URI[sha256sum] = "1c2d77242e1f30c4d1394636cae9f6877228a017960fca96881e0080d8b6e9c9"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
