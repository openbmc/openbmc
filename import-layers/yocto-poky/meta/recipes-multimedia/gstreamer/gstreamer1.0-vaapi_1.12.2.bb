require gstreamer1.0-vaapi.inc
SRC_URI[md5sum] = "bea015f33696a15ad9575fb71af862ed"
SRC_URI[sha256sum] = "23c714e0474b3c7ae6ff8884aebf8503a1bc3ded335fa2d2b2ac31788466163a"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
