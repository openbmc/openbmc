require gstreamer1.0-rtsp-server.inc

SRC_URI[md5sum] = "ef587fa6393e09bc26f884510596e305"
SRC_URI[sha256sum] = "2f6e12fd4e3568ee190dc24e57e4c3a878971c3a3fb6904a9674404fac256de6"

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"
