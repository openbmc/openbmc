require libgcrypt.inc

SRC_URI[md5sum] = "eac6d11999650e8a1493674c1bdbc7f8"
SRC_URI[sha256sum] = "fc0aec7714d75d812b665bd510d66031b1b2ce8fa855cc2c02238c954ea36982"
