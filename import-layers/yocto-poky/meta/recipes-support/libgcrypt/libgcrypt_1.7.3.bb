require libgcrypt.inc

SRC_URI[md5sum] = "bb5b00cb70b1215833857fd690080fbb"
SRC_URI[sha256sum] = "c98470cf6a781f2af4bdfda710ad39f0f54b5044e8c43b878d4005737d6c213f"
