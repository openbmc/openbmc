inherit setuptools
require python-six.inc

RDEPENDS_${PN} += "python-io"
