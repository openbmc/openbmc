FILESEXTRAPATHS_prepend := "${THISDIR}/python-pycurl:"

require python-pycurl.inc

inherit distutils3
