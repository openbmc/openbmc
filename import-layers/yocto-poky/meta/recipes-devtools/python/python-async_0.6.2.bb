require python-async.inc

inherit setuptools

RDEPENDS_${PN} += "python-threading python-lang"
