inherit setuptools3
require python-async.inc
