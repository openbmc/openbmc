inherit setuptools3
require python-six.inc
