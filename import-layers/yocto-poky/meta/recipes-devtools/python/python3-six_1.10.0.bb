inherit setuptools3
require python-six.inc

RDEPENDS_${PN} += "python3-io"
