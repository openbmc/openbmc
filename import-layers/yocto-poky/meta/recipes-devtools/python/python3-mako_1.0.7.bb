inherit setuptools3
require python-mako.inc
