require apt-native.inc

SRC_URI += "file://noconfigure.patch \
            file://no-curl.patch"
