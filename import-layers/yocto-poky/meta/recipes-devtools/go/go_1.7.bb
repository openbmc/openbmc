require go-${PV}.inc
require go.inc
