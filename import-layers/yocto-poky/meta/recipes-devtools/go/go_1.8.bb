require go-${PV}.inc
require go.inc
TUNE_CCARGS_remove = "-march=mips32r2"
