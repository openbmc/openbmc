require go-${PV}.inc
require go-target.inc
