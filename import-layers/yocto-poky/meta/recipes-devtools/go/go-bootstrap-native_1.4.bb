BOOTSTRAP = "1.4"
require go-native.inc
require go-${PV}.inc
