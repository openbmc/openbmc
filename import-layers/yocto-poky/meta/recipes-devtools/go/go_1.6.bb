require go.inc
require go-${PV}.inc

BBCLASSEXTEND = "cross"
