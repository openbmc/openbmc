require ${PN}.inc
require go-${PV}.inc
DEPENDS += "go-bootstrap-native"
