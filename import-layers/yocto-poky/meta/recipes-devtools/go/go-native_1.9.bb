require ${PN}.inc
require go-${PV}.inc
