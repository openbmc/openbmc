DUMMYARCH = "sdk-provides-dummy-target"

DUMMYPROVIDES = "\
    /bin/sh \
    /bin/bash \
    /usr/bin/env \
    /usr/bin/perl \
    pkgconfig \
"

require dummy-sdk-package.inc
