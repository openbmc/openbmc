SUMMARY = "OpenSSH SSH client/server"
LICENSE = "MIT"
PR = "r1"

inherit packagegroup

RDEPENDS_${PN} = "openssh"
