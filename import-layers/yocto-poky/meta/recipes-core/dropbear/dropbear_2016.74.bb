require dropbear.inc

SRC_URI += "file://support-out-of-tree-builds.patch"

SRC_URI[md5sum] = "9ad0172731e0f16623937804643b5bd8"
SRC_URI[sha256sum] = "2720ea54ed009af812701bcc290a2a601d5c107d12993e5d92c0f5f81f718891"

