require dbus-glib.inc

SRC_URI[md5sum] = "2eea0b7f52b49f600a07abfd8535d4e4"
SRC_URI[sha256sum] = "b38952706dcf68bad9c302999ef0f420b8cf1a2428227123f0ac4764b689c046"
