IMAGE_INSTALL += "container-image-testpkg"

LICENSE = "MIT"

IMAGE_FSTYPES = "container"
IMAGE_LINGUAS = ""

inherit core-image
