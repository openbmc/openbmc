RDEPENDS_${PN}_append_genericx86 = " lttng-ust systemtap"

