CONFLICTS = "vc-graphics-hardfp"

VCDIR = "opt/vc"
require vc-graphics.inc

PR = "${INCPR}.0"
