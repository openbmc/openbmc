EGLINFO_DEVICE_rpi  = "raspberrypi"
