PACKAGECONFIG_append_rpi = " gallium"
GALLIUMDRIVERS_rpi = "vc4"
DRIDRIVERS_rpi = ""
