EXTRA_OECONF_append_raspberrypi = " --disable-asm"
EXTRA_OECONF_append_raspberrypi0-wifi = " --disable-asm"
