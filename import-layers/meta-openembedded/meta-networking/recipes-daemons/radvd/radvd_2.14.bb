
require radvd.inc

SRC_URI[md5sum] = "acd3883dece2c7888d15596b05c9fae4"
SRC_URI[sha256sum] = "46d31c05daea11c3d1e3dc092997d3631b3bc72b20a4f279b05304b83dbd7aa8"
