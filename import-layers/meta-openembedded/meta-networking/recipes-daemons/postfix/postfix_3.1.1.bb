require postfix.inc

SRC_URI[md5sum] = "40d72ea143af7ab0038c2cee1f483707"
SRC_URI[sha256sum] = "3deda4c34631970490b1b5fbb559905f93531bf1c7eb00e38b0d0deb1dba9982"
