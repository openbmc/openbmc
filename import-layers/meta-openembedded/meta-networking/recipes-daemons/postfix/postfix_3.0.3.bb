require postfix.inc

SRC_URI[md5sum] = "61caffae689c11d09b4c972a394ae3b1"
SRC_URI[sha256sum] = "401e46ec3450569dcce60d1d8ca22a19ab1f7f817b0cc730cdf4875ba608ac02"
