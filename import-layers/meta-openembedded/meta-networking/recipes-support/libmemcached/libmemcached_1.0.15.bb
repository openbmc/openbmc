require libmemcached.inc

SRC_URI += "file://crosscompile.patch"

SRC_URI[md5sum] = "616297a1aedefc52b3f6922eda5d559a"
SRC_URI[sha256sum] = "dd7e9560029835bddf761a5b4c2339d9e5c7374558659b6c11b2c95e7d3a4325"
