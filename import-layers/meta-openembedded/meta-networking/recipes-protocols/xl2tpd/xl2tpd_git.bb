require xl2tpd.inc

# This is v1.3.6 plus some commits.  There is no tag for this commit.
#
PV = "1.3.6+git${SRCPV}"

SRCREV = "a96b345962622ea58490924130675df6db062d11"

