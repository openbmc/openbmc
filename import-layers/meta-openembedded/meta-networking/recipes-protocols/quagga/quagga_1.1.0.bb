require quagga.inc

SRC_URI[md5sum] = "daa303871e07ea5856aae6fd79e89722"
SRC_URI[sha256sum] = "f7a43a9c59bfd3722002210530b2553c8d5cc05bfea5acd56d4f102b9f55dc63"

QUAGGASUBDIR = ""
