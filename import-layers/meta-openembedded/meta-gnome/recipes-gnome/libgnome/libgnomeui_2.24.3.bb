require libgnomeui.inc

PR = "r1"

SRC_URI[archive.md5sum] = "ceab6f4370581d1a03c09f15cc103099"
SRC_URI[archive.sha256sum] = "04c81f3bb5a337cdf3ed1230916f82d29857ee95eb884f58dd2f5c6860efe803"
GNOME_COMPRESS_TYPE="bz2"
