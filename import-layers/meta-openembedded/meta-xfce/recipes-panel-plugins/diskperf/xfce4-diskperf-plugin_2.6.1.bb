SUMMARY = "Panel plugin displaying instant disk/partition performance"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-diskperf-plugin"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=d3e627798d6a60bece47aa8b3532e1f1"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "63d5f03934c2dbddb3ad7bf7f535cc23"
SRC_URI[sha256sum] = "212ddc742be3eecb6ad5554e1b1df03d5685cb71f48a558d5f895de37c57e4fa"
