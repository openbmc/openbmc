SUMMARY = "Panel plugin displaying current load of the network interfaces"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-netload-plugin"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=35a7203c41b86d15546dddc05995f97f"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "ce53e1135e4bff5afcd899627110bd11"
SRC_URI[sha256sum] = "fface918822c012d806717116566e54947ad7613b9290b45a18e2d5ffb8730d3"
