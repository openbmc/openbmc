SUMMARY = "Panel plugin displaying stats from a wireless lan interface"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-wavelan-plugin"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=e1e5872df9c5cf1a23f16493d9104920"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "b163b22f8543e5e5767a68af35c9028e"
SRC_URI[sha256sum] = "4d5bd6654cfd077f3432b08d296f7bd052e765e51b77c629886a9542f4e5ecdc"
