require nginx.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=3845852aedfa8d6d7765f55d06cc3ebd"

SRC_URI[md5sum] = "2e91695074dbdfbf1bcec0ada9fda462"
SRC_URI[sha256sum] = "8f4b3c630966c044ec72715754334d1fdf741caa1d5795fb4646c27d09f797b7"
