require nginx.inc

# 1.10.x branch is the current stable branch, the recommended default
# 1.11.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=903753de5f86a1ee0341fd2f9491b282"

SRC_URI[md5sum] = "6fb10f579055d27a2240d51c7d85c190"
SRC_URI[sha256sum] = "778b3cabb07633f754cd9dee32fc8e22582bce22bfa407be76a806abd935533d"
