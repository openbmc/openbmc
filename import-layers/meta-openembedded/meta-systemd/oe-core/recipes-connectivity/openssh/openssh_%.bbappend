RPROVIDES_${PN}-sshd += "${PN}-sshd-systemd"
RREPLACES_${PN}-sshd += "${PN}-sshd-systemd"
RCONFLICTS_${PN}-sshd += "${PN}-sshd-systemd"
