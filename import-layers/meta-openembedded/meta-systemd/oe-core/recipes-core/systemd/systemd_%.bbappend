RPROVIDES_udev += "udev-systemd"
RREPLACES_udev += "udev-systemd"
RCONFLICTS_udev += "udev-systemd"
