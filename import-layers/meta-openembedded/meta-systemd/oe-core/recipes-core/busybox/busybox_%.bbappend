RPROVIDES_${PN}-syslog += "${PN}-syslog-systemd"
RREPLACES_${PN}-syslog += "${PN}-syslog-systemd"
RCONFLICTS_${PN}-syslog += "${PN}-syslog-systemd"
