require ${BPN}.inc

SRC_URI[md5sum] = "f7c5d557336ea9df69bcca09c420711a"
SRC_URI[sha256sum] = "11e607b465cb66dafe05c66e02d61e09335b370fe9fd2a74d88282b3ee597bcc"
