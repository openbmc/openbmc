inherit nativesdk
include projucer.inc
BBCLASSEXTEND = "nativesdk"
