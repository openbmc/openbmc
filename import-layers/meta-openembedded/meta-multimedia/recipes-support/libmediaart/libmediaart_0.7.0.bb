require libmediaart.inc

SRC_URI[archive.md5sum] = "1a44933d4cd0064e3c76d8d0ddacddc9"
SRC_URI[archive.sha256sum] = "3a9dffcad862aed7c0921579b93080d694b8a66f3676bfee8037867f653a1cd3"
