require libmediaart.inc

SRC_URI = "${GNOME_MIRROR}/libmediaart/1.9/libmediaart-${PV}.tar.xz"
SRC_URI[md5sum] = "0b65d64398d2f3dff89534c9dfffab4f"
SRC_URI[sha256sum] = "94668adb29d4dc3115b0fd105942ebd5ca6f5f9dbb2afa8a191a73a747dd506f"

S = "${WORKDIR}/libmediaart-${PV}"
