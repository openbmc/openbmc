require libsexy.inc

PR = "r2"

SRC_URI[md5sum] = "33c079a253270ec8bfb9508e4bb30754"
SRC_URI[sha256sum] = "8c4101a8cda5fccbba85ba1a15f46f2cf75deaa8b3c525ce5b135b9e1a8fe49e"
