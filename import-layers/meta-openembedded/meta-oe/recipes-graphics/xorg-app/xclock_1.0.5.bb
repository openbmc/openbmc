require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "analog / digital clock for X"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=857759ade8f2ddde5c7b32ef7356ea36"

DEPENDS += " libxaw libxrender libxft libxkbfile libxt"

SRC_URI[md5sum] = "eaf124bbc9d13e1a12a29faaa2ed3612"
SRC_URI[sha256sum] = "53a9169e24f3814fbfcfee3ca0b98637840a3156ed7c7e36ae03940fabae4c9a"

