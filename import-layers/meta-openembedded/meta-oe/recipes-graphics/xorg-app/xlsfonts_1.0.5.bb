require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "server font list displayer for X"
HOMEPAGE = "http://cgit.freedesktop.org/xorg/app/xlsfonts/"
SECTION = "x11/app"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=5ec74dd7ea4d10c4715a7c44f159a40b"

SRC_URI[md5sum] = "6f5711bef8c765857a0887a91476283b"
SRC_URI[sha256sum] = "40295bec35077cee93be2e4c26cc00268ed6ace779ae6e97766a866c1e3927fa"
