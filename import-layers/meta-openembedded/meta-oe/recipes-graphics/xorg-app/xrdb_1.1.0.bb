require recipes-graphics/xorg-app/xorg-app-common.inc
SUMMARY = "X server resource database utility"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=d1167c4f586bd41f0c62166db4384a69"

DEPENDS += "libxmu"

SRC_URI[md5sum] = "b54c7e3e53b4f332d41ed435433fbda0"
SRC_URI[sha256sum] = "73827b6bbfc9d27ca287d95a1224c306d7053cd7b8156641698d7dc541ca565b"
