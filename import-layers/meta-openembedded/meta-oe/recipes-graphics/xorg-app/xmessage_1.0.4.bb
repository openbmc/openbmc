require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "Display a message or query in a window"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=73c7f696a728de728d7446cbca814cc5"

DEPENDS += "libxaw"

SRC_URI[md5sum] = "2dd5ae46fa18abc9331bc26250a25005"
SRC_URI[sha256sum] = "bcdf4b461c439bb3ade6e1e41c47d6218b912da8e9396b7ad70856db2f95ab68"
