# Copyright (C) 2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see meta-openembedded layer's COPYING.MIT)

TESSERACT_LANG = "jpn"

require tesseract-lang.inc

SRC_URI[md5sum] = "e1be2b08e667c3bb0ab0f18c9456bf2f"
SRC_URI[sha256sum] = "09bf447a29e990c065024b3b720fd70f08d596a7be534312fc9e47d0aabf681f"
