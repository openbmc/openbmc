# Copyright (C) 2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see meta-openembedded layer's COPYING.MIT)

TESSERACT_LANG = "lav"

require tesseract-lang.inc

SRC_URI[md5sum] = "2095b56c9c6b0dba9b837fd226ed6d29"
SRC_URI[sha256sum] = "e6a190ee1edf0a58948a9d7b01569fd8a4c05bc678da3a40ad884c0849958c36"
