# Copyright (C) 2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see meta-openembedded layer's COPYING.MIT)

TESSERACT_LANG = "glg"

require tesseract-lang.inc

SRC_URI[md5sum] = "ef7b8e13891e08f29b02011a5dd6b630"
SRC_URI[sha256sum] = "82ffa27c4de17545fa9d46e0fcd5690b1b59bcce9e93f71c0a41d19afbe869ee"
