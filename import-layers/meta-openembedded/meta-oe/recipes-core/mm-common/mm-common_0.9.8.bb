inherit gnomebase

GNOME_COMPRESS_TYPE="xz"

SRC_URI[archive.md5sum] = "00fd5c6850cd5fecc2e02b04d0dd1637"
SRC_URI[archive.sha256sum] = "c9ab5fd3872fbe245fbc35347acf4a95063111f81d54c43df3af662dad0a03d5"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

BBCLASSEXTEND = "native"

