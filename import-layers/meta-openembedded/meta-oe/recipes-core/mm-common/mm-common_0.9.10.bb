inherit gnomebase

GNOME_COMPRESS_TYPE="xz"

SRC_URI[archive.md5sum] = "49dc47af8c89ce5b3c768306b9a0f922"
SRC_URI[archive.sha256sum] = "16c0e2bc196b67fbc145edaecb5dbe5818386504fe5703de27002d77140fa217"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

BBCLASSEXTEND = "native"

