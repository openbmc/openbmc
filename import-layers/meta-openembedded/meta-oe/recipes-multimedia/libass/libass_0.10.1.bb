require ${PN}.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "6cace482a013a3c4bf3b31a68ac66026"
SRC_URI[sha256sum] = "629a7e81fff92dea8d0399b818a41fd1b61e381c67a5961b1eaec2efadb14c6c"
