require recipes-multimedia/${BPN}/${BPN}.inc

SRC_URI[md5sum] = "daa6cfca437c0776af5f79750cdd9b4e"
SRC_URI[sha256sum] = "f8a874d104e3e72e2cc057e5a1710c650b10367486845a26e5ff28ed7a912c2d"
