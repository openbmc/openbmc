require libmodbus.inc

# Use the stable branch by default
DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "dd4262f87ed835c4d1e560f8321a222c"
SRC_URI[sha256sum] = "661e14f9dc904f3f1b034464ddaa5fd4b8472f8f5d1ea10a1148af85591b7ee9"
