require glog.inc

SRC_URI = "http://google-glog.googlecode.com/files/glog-${PV}.tar.gz"

SRC_URI[md5sum] = "a6fd2c22f8996846e34c763422717c18"
SRC_URI[sha256sum] = "fbf90c2285ba0561db7a40f8a4eefb9aa963e7d399bd450363e959929fe849d0"
