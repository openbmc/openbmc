require augeas.inc

SRC_URI[md5sum] = "01190e455c513124a2dae29a1182c113"
SRC_URI[sha256sum] = "223bb6e6fe3e9e92277dafd5d34e623733eb969a72a382998d204feab253f73f"
