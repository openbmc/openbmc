include nano.inc

SRC_URI[md5sum] = "c011c7f9e47cb1da27d4e7cc8b56ec6a"
SRC_URI[sha256sum] = "752170643039e2c95a433de357f0c70a8c4c4c561a90a7e7259a63e225b659b9"
