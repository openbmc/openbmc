include nano.inc

SRC_URI[md5sum] = "6dd37f010d6a985bf0e5f8ed091ff919"
SRC_URI[sha256sum] = "7783bcfd4b2d5dc0bf64d4bd07b1a19e7ba3c91da881a4249772a36b972d4012"
