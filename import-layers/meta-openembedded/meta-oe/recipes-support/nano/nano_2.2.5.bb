include nano.inc

PR = "${INC_PR}.0"

SRC_URI += "file://ncursesw.includedir.patch"

SRC_URI[md5sum] = "77a10a49589f975ce98350a4527a2ebf"
SRC_URI[sha256sum] = "9015945d1badabbada203b37c4779d3dd1066234235c714deb439989c5cd7d9e"
