require ${BPN}.inc

SRC_URI[md5sum] = "7bbf4160876c12db6193c06e2badedb2"
SRC_URI[sha256sum] = "c0dac01938593deee06c3d161e4eda4ecc0fd7317e1321bd96e301aceb7fb027"
