inherit pypi setuptools
require python-pystache.inc
