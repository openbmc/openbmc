inherit pypi setuptools3
require python-certifi.inc
