inherit pypi setuptools3
require python-flask-uploads.inc
