inherit pypi setuptools3
require python-humanize.inc
