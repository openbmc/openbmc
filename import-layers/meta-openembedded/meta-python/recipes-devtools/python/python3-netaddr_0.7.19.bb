require python-netaddr.inc
inherit setuptools3
