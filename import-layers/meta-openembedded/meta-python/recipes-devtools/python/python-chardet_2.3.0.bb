SUMMARY = "Universal encoding detector for Python 2 and 3"
LICENSE = "LGPLv2.1"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a6f89e2100d9b6cdffcea4f398e37343"

SRC_URI[md5sum] = "25274d664ccb5130adae08047416e1a8"
SRC_URI[sha256sum] = "e53e38b3a4afe6d1132de62b7400a4ac363452dc5dfcf8d88e8e0cce663c68aa"

inherit pypi setuptools
