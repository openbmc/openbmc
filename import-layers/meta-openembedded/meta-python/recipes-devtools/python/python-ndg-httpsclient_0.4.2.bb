inherit pypi setuptools
require python-ndg-httpsclient.inc
