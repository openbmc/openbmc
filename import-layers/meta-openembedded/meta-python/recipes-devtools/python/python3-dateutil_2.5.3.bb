inherit setuptools3
require python-dateutil.inc
