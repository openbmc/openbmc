inherit setuptools3
require python-sqlalchemy.inc
