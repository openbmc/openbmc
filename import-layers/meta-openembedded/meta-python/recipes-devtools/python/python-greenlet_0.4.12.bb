inherit distutils
require python-greenlet.inc
