inherit pypi setuptools3
require python-cffi.inc
