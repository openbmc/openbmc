inherit setuptools
require python-bcrypt.inc
