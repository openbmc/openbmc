require python-can.inc
inherit pypi setuptools

RDEPENDS_${PN} += "python-sqlite3"
