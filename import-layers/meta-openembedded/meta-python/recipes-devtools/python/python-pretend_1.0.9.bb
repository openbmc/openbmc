inherit pypi setuptools
require python-pretend.inc
