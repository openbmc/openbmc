inherit setuptools3
require python-beautifulsoup4.inc
