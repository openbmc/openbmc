inherit pypi setuptools
require python-passlib.inc
