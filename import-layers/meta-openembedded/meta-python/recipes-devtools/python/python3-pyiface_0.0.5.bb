inherit setuptools3
require python-pyiface.inc
