inherit pypi setuptools
require python-flask.inc
