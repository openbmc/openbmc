inherit pypi setuptools3
require python-blinker.inc
