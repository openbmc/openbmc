inherit pypi setuptools
require python-blinker.inc
