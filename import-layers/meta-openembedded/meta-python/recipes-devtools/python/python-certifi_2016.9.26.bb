inherit pypi setuptools
require python-certifi.inc
