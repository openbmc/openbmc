inherit pypi setuptools3
require python-flask-pymongo.inc
