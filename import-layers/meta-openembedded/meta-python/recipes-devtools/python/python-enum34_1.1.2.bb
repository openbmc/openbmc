SUMMARY = "backport of Python 3.4's enum package"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://enum/LICENSE;md5=0a97a53a514564c20efd7b2e8976c87e"

SRC_URI[md5sum] = "025bb71b3f9d2fad15d0ee53e48dc873"
SRC_URI[sha256sum] = "2475d7fcddf5951e92ff546972758802de5260bf409319a9f1934e6bbc8b1dc7"

inherit pypi setuptools
