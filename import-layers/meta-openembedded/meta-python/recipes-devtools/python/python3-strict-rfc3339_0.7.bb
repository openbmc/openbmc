inherit pypi setuptools3
require python-strict-rfc3339.inc
