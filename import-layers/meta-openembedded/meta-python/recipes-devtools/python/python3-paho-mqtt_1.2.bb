inherit setuptools3
require python-paho-mqtt.inc

