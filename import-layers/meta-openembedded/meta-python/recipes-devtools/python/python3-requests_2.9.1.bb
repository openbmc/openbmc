inherit pypi setuptools3
require python-requests.inc
