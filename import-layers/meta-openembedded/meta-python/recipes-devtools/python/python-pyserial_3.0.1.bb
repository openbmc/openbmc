inherit setuptools
require python-pyserial.inc
