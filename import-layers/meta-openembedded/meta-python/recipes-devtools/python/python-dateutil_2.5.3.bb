inherit setuptools
require python-dateutil.inc
