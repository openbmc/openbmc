inherit pypi setuptools
require python-redis.inc
