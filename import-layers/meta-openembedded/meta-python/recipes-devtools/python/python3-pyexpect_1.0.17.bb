inherit setuptools3
require python-pyexpect.inc
