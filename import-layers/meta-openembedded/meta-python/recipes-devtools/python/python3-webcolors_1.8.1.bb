inherit pypi setuptools3
require python-webcolors.inc
