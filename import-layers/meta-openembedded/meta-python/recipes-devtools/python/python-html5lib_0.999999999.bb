inherit setuptools
require python-html5lib.inc
