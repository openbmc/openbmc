require python-pexpect.inc
inherit pypi setuptools3
