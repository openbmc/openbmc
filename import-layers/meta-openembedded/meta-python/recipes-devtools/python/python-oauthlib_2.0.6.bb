inherit setuptools
require python-oauthlib.inc

RDEPENDS_${PN} += "${PYTHON_PN}-re ${PYTHON_PN}-lang"
