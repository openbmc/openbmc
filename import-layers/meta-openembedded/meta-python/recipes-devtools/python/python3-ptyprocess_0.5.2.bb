require python-ptyprocess.inc
inherit pypi setuptools3
