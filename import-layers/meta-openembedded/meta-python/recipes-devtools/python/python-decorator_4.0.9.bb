inherit setuptools
require python-decorator.inc
