inherit pypi setuptools3
require python-werkzeug.inc
