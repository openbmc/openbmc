inherit setuptools3 pypi
require python-sdnotify.inc
