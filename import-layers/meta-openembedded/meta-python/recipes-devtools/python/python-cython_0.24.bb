inherit setuptools
require python-cython.inc

RDEPENDS_${PN} += "\
    python-distribute \
"
