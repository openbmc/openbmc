inherit setuptools python-dir
require python-scrypt.inc

