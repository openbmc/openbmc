inherit setuptools
require python-pyusb.inc
