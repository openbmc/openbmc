inherit pypi setuptools3
require python-passlib.inc