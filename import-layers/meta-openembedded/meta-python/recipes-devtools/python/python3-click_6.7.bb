inherit pypi setuptools3
require python-click.inc

RDEPENDS_${PN} += "${PYTHON_PN}-enum"
