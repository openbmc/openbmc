inherit pypi setuptools
require python-pymisp.inc
