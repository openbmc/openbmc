inherit setuptools3
require python-isort.inc
