inherit pypi setuptools3
require python-visitor.inc
