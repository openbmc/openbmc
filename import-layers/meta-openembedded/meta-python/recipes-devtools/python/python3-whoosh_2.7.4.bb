inherit pypi setuptools3
require python-whoosh.inc
