inherit pypi setuptools3
require python-flask-sqlalchemy.inc
