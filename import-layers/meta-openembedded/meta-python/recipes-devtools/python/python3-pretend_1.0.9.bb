inherit pypi setuptools3
require python-pretend.inc
