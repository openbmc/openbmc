inherit pypi setuptools3
require python-pysocks.inc
