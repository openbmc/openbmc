inherit setuptools
require python-appdirs.inc
