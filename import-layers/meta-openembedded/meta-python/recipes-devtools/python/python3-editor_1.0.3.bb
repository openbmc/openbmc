inherit pypi setuptools3
require python-editor.inc
