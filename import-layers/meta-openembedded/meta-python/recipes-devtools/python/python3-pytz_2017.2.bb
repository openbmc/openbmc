inherit setuptools3
require python-pytz.inc
