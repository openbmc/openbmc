inherit distutils
require python-smbus.inc
