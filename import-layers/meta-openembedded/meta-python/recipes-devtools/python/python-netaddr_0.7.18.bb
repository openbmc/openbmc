SUMMARY = "A network address manipulation library for Python."
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b277425f87f3b06d25af45d8b96f9682"

SRC_URI[md5sum] = "c65bb34f8bedfbbca0b316c490cd13a0"
SRC_URI[sha256sum] = "a1f5c9fcf75ac2579b9995c843dade33009543c04f218ff7c007b3c81695bd19"

inherit pypi setuptools
