inherit pypi setuptools3
require python-ndg-httpsclient.inc
