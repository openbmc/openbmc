inherit pypi setuptools
require python-cffi.inc
