inherit setuptools
require python-chardet.inc
