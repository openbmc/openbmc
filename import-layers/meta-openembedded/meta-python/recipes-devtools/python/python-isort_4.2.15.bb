inherit setuptools
require python-isort.inc
