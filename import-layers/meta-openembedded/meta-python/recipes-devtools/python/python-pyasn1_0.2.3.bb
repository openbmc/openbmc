inherit pypi setuptools
require python-pyasn1.inc
