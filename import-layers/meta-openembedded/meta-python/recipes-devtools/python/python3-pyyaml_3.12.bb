inherit setuptools3
require python-pyyaml.inc
