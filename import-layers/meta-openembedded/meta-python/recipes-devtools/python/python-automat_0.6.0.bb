inherit setuptools
require python-automat.inc
