inherit setuptools
require python-simplejson.inc

RDEPENDS_${PN} += "${PYTHON_PN}-re"
