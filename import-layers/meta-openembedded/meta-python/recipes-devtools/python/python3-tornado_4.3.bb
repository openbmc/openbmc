inherit pypi setuptools3
require python-tornado.inc
