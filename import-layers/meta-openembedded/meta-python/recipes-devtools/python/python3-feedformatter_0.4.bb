inherit setuptools3
require python-feedformatter.inc
