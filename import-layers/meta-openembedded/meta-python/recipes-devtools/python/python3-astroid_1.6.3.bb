inherit setuptools3
require python-astroid.inc
