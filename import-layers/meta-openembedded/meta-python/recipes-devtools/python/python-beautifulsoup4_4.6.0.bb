inherit setuptools
require python-beautifulsoup4.inc
