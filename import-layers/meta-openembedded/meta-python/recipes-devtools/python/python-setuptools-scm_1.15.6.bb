inherit setuptools
require python-setuptools-scm.inc
