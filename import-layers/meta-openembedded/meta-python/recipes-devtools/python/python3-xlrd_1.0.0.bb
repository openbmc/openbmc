inherit pypi setuptools3
require python-xlrd.inc
