inherit pypi setuptools
require python-whoosh.inc
