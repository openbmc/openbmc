inherit pypi setuptools
require python-werkzeug.inc
