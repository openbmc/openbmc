inherit setuptools3
require python-pytest-runner.inc
