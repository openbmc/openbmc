inherit pypi setuptools3
require python-urllib3.inc
