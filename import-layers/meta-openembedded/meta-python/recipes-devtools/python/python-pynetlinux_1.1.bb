inherit setuptools
require python-pynetlinux.inc
