inherit setuptools
require python-asn1crypto.inc
