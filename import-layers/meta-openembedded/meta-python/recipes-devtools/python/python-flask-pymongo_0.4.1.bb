inherit pypi setuptools
require python-flask-pymongo.inc
