inherit setuptools3
require python-serpent.inc
