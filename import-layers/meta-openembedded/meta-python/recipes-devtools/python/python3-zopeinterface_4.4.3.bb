inherit pypi setuptools3
require python-zopeinterface.inc

RDEPENDS_${PN}-test += "python3-unittest python3-doctest"
