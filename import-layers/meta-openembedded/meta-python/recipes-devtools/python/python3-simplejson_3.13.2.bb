inherit setuptools3
require python-simplejson.inc
