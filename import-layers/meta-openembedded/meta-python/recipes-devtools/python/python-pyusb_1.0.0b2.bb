inherit distutils
require python-pyusb.inc
