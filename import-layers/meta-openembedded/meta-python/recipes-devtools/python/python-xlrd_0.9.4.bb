inherit pypi setuptools
require python-xlrd.inc
