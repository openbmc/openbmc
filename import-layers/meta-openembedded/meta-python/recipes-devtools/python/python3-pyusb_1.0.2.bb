inherit setuptools3
require python-pyusb.inc
