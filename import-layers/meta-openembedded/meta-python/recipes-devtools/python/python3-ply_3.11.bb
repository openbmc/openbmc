require python-ply.inc
inherit setuptools3
