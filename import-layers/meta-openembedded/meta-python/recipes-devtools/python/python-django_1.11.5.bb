require python-django.inc
inherit setuptools
