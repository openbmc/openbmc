inherit pypi setuptools3
require python-pytest.inc
