inherit pypi setuptools
require python-flask-sqlalchemy.inc
