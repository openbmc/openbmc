inherit pypi setuptools
require python-itsdangerous.inc
