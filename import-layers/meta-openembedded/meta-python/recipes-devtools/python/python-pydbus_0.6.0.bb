require python-pydbus.inc
inherit pypi setuptools
