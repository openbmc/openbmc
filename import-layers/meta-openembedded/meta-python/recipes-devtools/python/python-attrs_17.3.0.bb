inherit setuptools
require python-attrs.inc
