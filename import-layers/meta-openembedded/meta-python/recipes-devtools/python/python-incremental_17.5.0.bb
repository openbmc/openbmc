inherit setuptools
require python-incremental.inc
