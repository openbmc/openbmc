inherit setuptools
require python-lazy-object-proxy.inc
