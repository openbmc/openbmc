SUMMARY = "Python Atom and RSS feed parser"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c21a7713ef6dc1b99644061c397e7c2a"

SRC_URI[md5sum] = "d552f7a2a55e8e33b2a3fe1082505b42"
SRC_URI[sha256sum] = "bd030652c2d08532c034c27fcd7c85868e7fa3cb2b17f230a44a6bbc92519bf9"

inherit pypi setuptools

