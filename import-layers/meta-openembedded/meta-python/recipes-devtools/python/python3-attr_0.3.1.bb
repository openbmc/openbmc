inherit setuptools3
require python-attr.inc
