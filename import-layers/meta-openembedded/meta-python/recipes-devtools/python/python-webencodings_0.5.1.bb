inherit setuptools
require python-webencodings.inc
