require python-cffi.inc
inherit pypi setuptools
