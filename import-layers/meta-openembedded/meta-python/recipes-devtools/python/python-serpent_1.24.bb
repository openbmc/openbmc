inherit setuptools
require python-serpent.inc
