DESCRIPTION = "An extension that includes Bootstrap in your project, without any boilerplate code."
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=f270fbb7d3ea88731bfc00916750c6bc"

SRC_URI[md5sum] = "4471ad68dbf71a3c68e00bd0e1301a9f"
SRC_URI[sha256sum] = "020bf9fcca6d69dce3b19bcb80852da929a2b1adde6cb4d47a4402f5ce54ef78"

PYPI_PACKAGE = "Flask-Bootstrap"

inherit pypi setuptools
