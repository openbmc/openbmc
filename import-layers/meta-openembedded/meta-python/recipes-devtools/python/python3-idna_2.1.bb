inherit pypi setuptools3
require python-idna.inc
