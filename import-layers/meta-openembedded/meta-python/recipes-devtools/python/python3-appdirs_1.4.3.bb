inherit setuptools3
require python-appdirs.inc
