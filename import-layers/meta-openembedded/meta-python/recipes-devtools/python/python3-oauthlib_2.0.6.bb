inherit setuptools3
require python-oauthlib.inc
