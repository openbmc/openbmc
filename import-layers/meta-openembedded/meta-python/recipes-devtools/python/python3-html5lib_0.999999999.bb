inherit setuptools3
require python-html5lib.inc
