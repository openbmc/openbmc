require python-gevent.inc
inherit setuptools

