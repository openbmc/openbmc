inherit setuptools3
require python-pyinotify.inc
