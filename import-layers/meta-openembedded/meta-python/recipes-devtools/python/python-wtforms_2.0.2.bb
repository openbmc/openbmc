DESCRIPTION = "A flexible forms validation and rendering library for python web development."
HOMEPAGE = "https://pypi.python.org/pypi/WTForms"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=e9377f5e4bfad82b40ed63f0fd4d1cce"

SRC_URI[md5sum] = "613cf723ab40537705bec02733c78d95"
SRC_URI[sha256sum] = "10737758ceae03b53021f3aa7e81bfc8dd6f679c879ffeb5e64ac6570facb6c1"

PYPI_PACKAGE = "WTForms"
PYPI_PACKAGE_EXT = "zip"

inherit pypi setuptools
