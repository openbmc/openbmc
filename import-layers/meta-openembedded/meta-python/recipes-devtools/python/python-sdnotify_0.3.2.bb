inherit setuptools pypi
require python-sdnotify.inc
