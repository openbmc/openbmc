inherit pypi setuptools
require python-evdev.inc
