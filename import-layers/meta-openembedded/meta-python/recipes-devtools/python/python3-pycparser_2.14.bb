inherit pypi setuptools3
require python-pycparser.inc
