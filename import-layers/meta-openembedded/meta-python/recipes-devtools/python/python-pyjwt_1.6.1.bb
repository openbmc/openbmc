require python-pyjwt.inc
inherit setuptools
