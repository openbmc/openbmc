inherit setuptools
require python-constantly.inc
