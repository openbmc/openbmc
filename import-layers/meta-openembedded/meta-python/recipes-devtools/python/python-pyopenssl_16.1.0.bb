inherit pypi setuptools
require python-pyopenssl.inc
