require python-unidiff.inc
inherit setuptools3
