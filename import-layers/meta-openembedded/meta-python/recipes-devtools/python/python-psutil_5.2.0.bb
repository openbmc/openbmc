inherit pypi setuptools
require python-psutil.inc
