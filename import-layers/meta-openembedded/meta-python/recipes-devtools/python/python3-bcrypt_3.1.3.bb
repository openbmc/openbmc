inherit setuptools3
require python-bcrypt.inc
