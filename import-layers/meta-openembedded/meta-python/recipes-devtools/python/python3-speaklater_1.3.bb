inherit pypi setuptools3
require python-speaklater.inc
