inherit pypi setuptools3
require python-alembic.inc
