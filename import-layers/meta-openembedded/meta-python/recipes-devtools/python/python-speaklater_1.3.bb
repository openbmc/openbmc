inherit pypi setuptools
require python-speaklater.inc
