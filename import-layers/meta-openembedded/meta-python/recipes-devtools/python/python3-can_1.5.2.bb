require python-can.inc
inherit pypi setuptools3

RDEPENDS_${PN} += "python3-sqlite3"
