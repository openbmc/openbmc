inherit setuptools
require python-pyinotify.inc
