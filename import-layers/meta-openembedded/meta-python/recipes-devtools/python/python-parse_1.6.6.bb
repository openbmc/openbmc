SUMMARY = "Parse strings using a specification based on the Python format() syntax"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://parse.py;md5=e067ba2a08b73721dbe7356dc0282918;startline=1108;endline=1126"

SRC_URI[md5sum] = "11bc8c60a30fe52db4ac9a827653d0ca"
SRC_URI[sha256sum] = "71435aaac494e08cec76de646de2aab8392c114e56fe3f81c565ecc7eb886178"

inherit pypi setuptools
