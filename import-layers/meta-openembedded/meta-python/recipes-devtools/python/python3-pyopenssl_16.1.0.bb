inherit pypi setuptools3
require python-pyopenssl.inc
