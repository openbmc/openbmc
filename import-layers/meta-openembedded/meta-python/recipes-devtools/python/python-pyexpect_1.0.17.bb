inherit setuptools
require python-pyexpect.inc
