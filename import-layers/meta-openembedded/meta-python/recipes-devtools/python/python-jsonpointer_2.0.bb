inherit setuptools
require python-jsonpointer.inc

RDEPENDS_${PN} += "${PYTHON_PN}-re"
