inherit pypi setuptools3
require python-flask-user.inc
