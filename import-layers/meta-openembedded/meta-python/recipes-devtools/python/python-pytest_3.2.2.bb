inherit pypi setuptools
require python-pytest.inc
