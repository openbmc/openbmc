inherit setuptools3
require python-pyfirmata.inc

