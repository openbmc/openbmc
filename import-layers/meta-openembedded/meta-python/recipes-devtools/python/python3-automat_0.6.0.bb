inherit setuptools3
require python-automat.inc

RDEPENDS_${PN} += "${PYTHON_PN}-enum "
