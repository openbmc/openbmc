inherit pypi setuptools
require python-jinja2.inc
