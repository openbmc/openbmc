inherit pypi setuptools
require python-flask-login.inc
