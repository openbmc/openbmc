inherit pypi setuptools3
require python-cryptography-vectors.inc
