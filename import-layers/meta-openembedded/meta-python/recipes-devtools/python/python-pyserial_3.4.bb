inherit setuptools
require python-pyserial.inc

RDEPENDS_${PN} += "${PYTHON_PN}-argparse"
