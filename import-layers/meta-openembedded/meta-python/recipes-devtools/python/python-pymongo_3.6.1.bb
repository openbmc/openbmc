inherit pypi setuptools
require python-pymongo.inc
