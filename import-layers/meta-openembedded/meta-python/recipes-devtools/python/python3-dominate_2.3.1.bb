inherit pypi setuptools3
require python-dominate.inc
