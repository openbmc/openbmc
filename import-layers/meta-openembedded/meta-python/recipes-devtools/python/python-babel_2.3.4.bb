inherit setuptools
require python-babel.inc
