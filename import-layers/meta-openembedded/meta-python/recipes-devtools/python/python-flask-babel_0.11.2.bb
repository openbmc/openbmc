inherit pypi setuptools
require python-flask-babel.inc
