inherit pypi setuptools
require python-humanize.inc
