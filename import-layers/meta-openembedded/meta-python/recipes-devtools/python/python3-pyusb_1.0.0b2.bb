inherit distutils3
require python-pyusb.inc
