inherit pypi setuptools
require python-typing.inc
