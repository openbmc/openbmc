inherit setuptools
require python-paho-mqtt.inc

