inherit setuptools
require python-decorator.inc

RDEPENDS_${PN} += "${PYTHON_PN}-contextlib"
