inherit setuptools
require python-lxml.inc
