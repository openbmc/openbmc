inherit setuptools
require python-simplejson.inc
