inherit pypi setuptools
require python-py.inc
