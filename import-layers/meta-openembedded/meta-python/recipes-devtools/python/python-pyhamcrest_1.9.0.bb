SUMMARY = "Hamcrest framework for matcher objects"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f6df1318c6071dd1707f5e3b6c11f24f"

PYPI_PACKAGE = "PyHamcrest"

SRC_URI[md5sum] = "8b833a3fa30197455df79424f30c8c3f"
SRC_URI[sha256sum] = "8ffaa0a53da57e89de14ced7185ac746227a8894dbd5a3c718bf05ddbd1d56cd"

inherit pypi setuptools
