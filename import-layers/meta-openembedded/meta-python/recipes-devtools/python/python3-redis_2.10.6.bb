inherit pypi setuptools3
require python-redis.inc
