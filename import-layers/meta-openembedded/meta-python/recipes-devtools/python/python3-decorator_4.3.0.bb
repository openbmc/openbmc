inherit setuptools3
require python-decorator.inc
