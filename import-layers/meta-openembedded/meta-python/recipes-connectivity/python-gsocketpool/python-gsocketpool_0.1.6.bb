require python-gsocketpool.inc
inherit setuptools
