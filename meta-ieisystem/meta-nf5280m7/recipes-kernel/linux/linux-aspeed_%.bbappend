FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI:append: = " \
    file://nf5280m7.cfg \
"
