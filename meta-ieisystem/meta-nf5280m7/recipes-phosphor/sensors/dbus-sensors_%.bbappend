PACKAGECONFIG = " \
        adcsensor \
        fansensor \
        hwmontempsensor \
        intelcpusensor \
        ipmbsensor \
        nvmesensor \
        psuensor \
        "
