DEPENDS:append = " nf5280m7-yaml-config"

IPMI_FRU_YAML = "${STAGING_DIR_HOST}${datadir}/nf5280m7-yaml-config/ipmi-fru-read.yaml"
IPMI_FRU_PROP_YAML = "${STAGING_DIR_HOST}${datadir}/nf5280m7-yaml-config/ipmi-extra-properties.yaml"
