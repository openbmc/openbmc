TRACE_EVENTS:append = " \
    i2c \
    i2c_slave \
"
