RDEPENDS:${PN}-extras:append = " \
        iei-ipmi-oem \
        phosphor-virtual-sensor \
        tzdata-core \
        "

RDEPENDS:${PN}-devtools:append = " \
        ipmitool \
        "

