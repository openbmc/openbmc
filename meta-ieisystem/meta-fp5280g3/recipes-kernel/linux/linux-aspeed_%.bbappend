FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI:append: = " \
    file://fp5280g3.cfg \
"
