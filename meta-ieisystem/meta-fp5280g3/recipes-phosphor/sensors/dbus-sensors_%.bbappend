PACKAGECONFIG = " \
    adcsensor \
    fansensor \
    hwmontempsensor \
    nvmesensor \
    psusensor \
    "

