DEPENDS:append = " pdbg ipl"

EXTRA_OEMESON:append = " -Dmax-cpus=4"
