require u-boot-common.inc
require u-boot-tools.inc

SRC_URI += "file://0001-scripts-dtc-drop-yaml-in-DT-validation.patch"
