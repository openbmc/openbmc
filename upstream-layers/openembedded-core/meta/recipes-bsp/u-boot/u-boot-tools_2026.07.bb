require u-boot-common.inc
require u-boot-tools.inc

SRC_URI += "file://0001-tools-mkeficapsule-Detect-GnuTLS-PKCS-11-support.patch"
