inherit cross-canadian
require rust-cross-canadian.inc