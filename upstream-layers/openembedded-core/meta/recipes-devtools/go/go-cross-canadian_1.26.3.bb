require go-cross-canadian.inc
require go-${PV}.inc
