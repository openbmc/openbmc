require quilt.inc
inherit gettext

