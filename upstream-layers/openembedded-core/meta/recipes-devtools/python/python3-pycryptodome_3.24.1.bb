require python-pycryptodome.inc
inherit python_setuptools_build_meta

SRC_URI[sha256sum] = "3f9e74444c0ecbec7af232a95d282c74b114d53212ce075ed17b7fd7dca32bb3"

CVE_PRODUCT = "pycryptodome:pycryptodome"
