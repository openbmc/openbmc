require python-pycryptodome.inc
inherit python_setuptools_build_meta

SRC_URI[sha256sum] = "447700a657182d60338bab09fdb27518f8856aecd80ae4c6bdddb67ff5da44ef"

