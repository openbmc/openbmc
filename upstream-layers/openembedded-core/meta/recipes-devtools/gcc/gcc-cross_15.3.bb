require recipes-devtools/gcc/gcc-${PV}.inc
require gcc-cross.inc

