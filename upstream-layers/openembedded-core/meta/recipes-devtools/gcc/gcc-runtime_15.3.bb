require recipes-devtools/gcc/gcc-${PV}.inc
require gcc-runtime.inc
