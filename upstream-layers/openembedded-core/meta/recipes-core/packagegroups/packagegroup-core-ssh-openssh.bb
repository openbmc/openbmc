SUMMARY = "OpenSSH SSH client/server"

inherit packagegroup

RDEPENDS:${PN} = "openssh"
