require glib.inc
PACKAGES = ""
PACKAGECONFIG = ""

inherit nopackages

