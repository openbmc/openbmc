SOURCEFORGE_PROJECT ?= "${BPN}"
UPSTREAM_CHECK_URI = "https://sourceforge.net/projects/${SOURCEFORGE_PROJECT}/files/"
