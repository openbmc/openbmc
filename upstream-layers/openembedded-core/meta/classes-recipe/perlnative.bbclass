#
# Copyright OpenEmbedded Contributors
#
# SPDX-License-Identifier: MIT
#

EXTRANATIVEPATH += "perl-native"
DEPENDS += "perl-native"
OECMAKE_PERLNATIVE_DIR = "${STAGING_BINDIR_NATIVE}/perl-native"
