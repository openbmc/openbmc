#
# Copyright OpenEmbedded Contributors
#
# SPDX-License-Identifier: MIT
#

deltask do_create_recipe_spdx
deltask do_create_spdx
deltask do_create_spdx_runtime
deltask do_create_package_spdx
deltask do_create_rootfs_spdx
deltask do_create_image_spdx
deltask do_create_image_sbom
