#
# Copyright OpenEmbedded Contributors
#
# SPDX-License-Identifier: MIT
#

SUMMARY = "A C++ example compiled with cmake and GCC."

require cmake-example.inc

TOOLCHAIN = "gcc"
