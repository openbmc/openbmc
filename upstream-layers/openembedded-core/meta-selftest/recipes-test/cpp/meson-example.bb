#
# Copyright OpenEmbedded Contributors
#
# SPDX-License-Identifier: MIT
#

SUMMARY = "A C++ example compiled with meson and GCC."

require meson-example.inc

TOOLCHAIN = "gcc"
