require gitunpackoffline.inc

TAGVALUE = "2.11"

PV = "0.0+git"
