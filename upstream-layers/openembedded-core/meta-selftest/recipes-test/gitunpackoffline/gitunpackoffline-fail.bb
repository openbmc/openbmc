require gitunpackoffline.inc

# Clear the base.bbclass magic srcrev call
fetcher_hashes_dummyfunc[vardepvalue] = ""
