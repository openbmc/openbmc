LICENSE = "CLOSED"
INHIBIT_DEFAULT_DEPS = "1"

SRC_URI = "file://file1"

S = "${UNPACKDIR}"

EXCLUDE_FROM_WORLD = "1"
