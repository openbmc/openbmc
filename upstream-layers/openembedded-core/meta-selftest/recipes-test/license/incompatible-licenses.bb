SUMMARY = "Recipe with multiple SPDX licenses"
DESCRIPTION = "Is licensed with multiple SPDX licenses to be used for testing"
LICENSE = "GPL-2.0-only AND GPL-3.0-only AND LGPL-3.0-only"

EXCLUDE_FROM_WORLD = "1"
