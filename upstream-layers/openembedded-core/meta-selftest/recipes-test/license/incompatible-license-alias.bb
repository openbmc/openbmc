SUMMARY = "Recipe with an alias of an SPDX license"
DESCRIPTION = "Is licensed with an alias of an SPDX license to be used for testing"
LICENSE = "GPL-3.0-only"

EXCLUDE_FROM_WORLD = "1"
