SUMMARY = "Virtual provider sysroot test"
LICENSE = "CLOSED"
INHIBIT_DEFAULT_DEPS = "1"
DEPENDS = "virtual/sysroot-test"

EXCLUDE_FROM_WORLD = "1"
