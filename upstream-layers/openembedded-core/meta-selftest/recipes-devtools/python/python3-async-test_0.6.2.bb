inherit setuptools3
require python-async-test.inc
