python () {
    d.setVar("TEST_SET_FROM_ANON_FUNC", "expected value")
}
