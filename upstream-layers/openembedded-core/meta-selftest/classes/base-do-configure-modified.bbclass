base_do_configure:append () {
	echo "this changes base_do_configure() definiton "
}
