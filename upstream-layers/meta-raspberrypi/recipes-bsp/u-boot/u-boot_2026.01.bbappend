FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://8de24e226d7.patch"
