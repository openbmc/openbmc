# SPDX-FileCopyrightText: Andrei Gherzan <andrei.gherzan@huawei.com>
#
# SPDX-License-Identifier: MIT

require linux-raspberrypi-v7.inc
require linux-raspberrypi_6.1.bb
