CONFLICTS = "vc-graphics"

VCDIR = "hardfp/opt/vc"
require vc-graphics.inc

PR = "${INCPR}.0"
