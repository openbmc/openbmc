SUMMARY = "A powerful declarative symmetric parser/builder for binary data"
HOMEPAGE = "https://github.com/construct/construct"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=202b39559c1c79fe4715ce81e9e0ac02"

PYPI_PACKAGE = "construct"

SRC_URI[sha256sum] = "7b2a3fd8e5f597a5aa1d614c3bd516fa065db01704c72a1efaaeec6ef23d8b45"

inherit pypi
inherit setuptools3
inherit native
