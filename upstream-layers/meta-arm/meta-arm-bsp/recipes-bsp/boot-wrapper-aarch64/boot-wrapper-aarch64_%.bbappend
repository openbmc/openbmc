COMPATIBLE_MACHINE:fvp-base = "fvp-base"
