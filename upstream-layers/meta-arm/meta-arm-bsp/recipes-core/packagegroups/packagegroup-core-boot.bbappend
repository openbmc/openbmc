# Customise core boot package for corstone1000 initramfs by removing GRUB

RDEPENDS:${PN}:remove:corstone1000 = "grub-efi"