# Use custom interface file for Juno

#
# Enable second network interface on startup
#
PACKAGE_ARCH = "${MACHINE_ARCH}"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
