PSA_TEST_TS_REQUIRE ?= ""
PSA_TEST_TS_REQUIRE:corstone1000 = "ts-psa-api-test-corstone1000.inc"

require ${PSA_TEST_TS_REQUIRE}

require ts-arm-platforms.inc
