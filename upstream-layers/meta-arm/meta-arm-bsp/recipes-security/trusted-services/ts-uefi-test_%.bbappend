require ts-arm-platforms.inc
