require recipes-security/optee/optee-os.inc

DEPENDS += "dtc-native"

# 4.10.0
SRCREV = "753afbbee1682f5d16fd30e87b31058a4fd4f4b8"
