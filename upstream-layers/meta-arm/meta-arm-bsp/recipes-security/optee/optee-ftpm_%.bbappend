COMPATIBLE_MACHINE:sbsa-ref = "sbsa-ref"
