require recipes-security/optee/optee-client.inc

# v4.11.0
SRCREV = "da81fb7b30781029bc9d4acfddc7c60b08deb1f3"
