require recipes-security/optee/optee-client.inc

# 4.9.0 and 4.10.0 share the same tag
SRCREV = "9f5e90918093c1d1cd264d8149081b64ab7ba672"
