require recipes-security/optee/optee-os.inc

DEPENDS += "dtc-native"

# 4.9.0
SRCREV = "c2b0684fcd89929976a8726e6e3af922b48dd2c7"
