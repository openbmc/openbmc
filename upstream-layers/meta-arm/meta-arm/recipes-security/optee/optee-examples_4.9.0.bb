require recipes-security/optee/optee-examples.inc

# v4.9.0
SRCREV = "934c7edb74a26e90f68024cf441073528444177f"
