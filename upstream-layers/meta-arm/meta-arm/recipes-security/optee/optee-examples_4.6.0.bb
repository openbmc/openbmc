require recipes-security/optee/optee-examples.inc

# v4.6.0
SRCREV = "5306d2c7c618bb4a91df17a2d5d79ae4701af4a3"
