require recipes-bsp/uefi/edk2-firmware.inc

SRCREV_edk2           ?= "b03a21a63e3bd001f52c527e5a57feddb53a690b"
SRCREV_edk2-platforms ?= "04470160f67192c53ec9192e0e8460d183fe49ec"
