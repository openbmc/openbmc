SUMMARY = "Machine specific gpsd config"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/BSD-3-Clause;md5=550794465ba0ec5312d6919e203a55f9"

# empty by default
# BSP layers can add stuff like meta-openmoko example:
#
ALLOW_EMPTY:${PN} = "1"
