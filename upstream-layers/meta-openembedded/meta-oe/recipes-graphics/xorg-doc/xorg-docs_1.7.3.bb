require xorg-doc-common.inc

SUMMARY = "Documentation for the X Window System"

LIC_FILES_CHKSUM = "file://general/License.xml;md5=f2677c20a4066714e233e9bbd8659aa2"

SRC_URI_EXT = "xz"

SRC_URI[sha256sum] = "28a2f2eeb5d9ff58b85961ff3ed7baaaf1ffa132e2a81f8b2bb97cb499bcddef"
