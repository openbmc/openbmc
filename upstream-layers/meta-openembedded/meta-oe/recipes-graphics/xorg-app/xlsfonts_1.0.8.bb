require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "server font list displayer for X"
HOMEPAGE = "http://cgit.freedesktop.org/xorg/app/xlsfonts/"
SECTION = "x11/app"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=5ec74dd7ea4d10c4715a7c44f159a40b"

SRC_URI_EXT = "xz"
SRC_URI[sha256sum] = "807f909eace684b866fc63b3e962729c120822a6c96e051ff51cf350b3ffb6cd"
