require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "server font list displayer for X"
HOMEPAGE = "http://cgit.freedesktop.org/xorg/app/xlsfonts/"
SECTION = "x11/app"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=5ec74dd7ea4d10c4715a7c44f159a40b"

SRC_URI_EXT = "xz"
SRC_URI[sha256sum] = "a6a2e291801458d92510263b175d16f98024dc3816ebddbde79b5009f6c3b065"
