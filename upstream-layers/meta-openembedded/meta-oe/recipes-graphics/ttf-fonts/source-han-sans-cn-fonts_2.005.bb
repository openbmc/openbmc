require source-han-sans-fonts.inc

SUMMARY = "Adobe OpenType Pan-CJK font family for Simplified Chinese"
ZIPNAME = "19_SourceHanSansCN"

SRC_URI[sha256sum] = "3a769d1b082ebd813cdb4c06ea57d29b340bce548edcc8e61976b78ca28e6236"
