require source-han-sans-fonts.inc

SUMMARY = "Adobe OpenType Pan-CJK font family for Traditional Chinese"
ZIPNAME = "20_SourceHanSansTW"

SRC_URI[sha256sum] = "2cbfe304a4d794725d5c1873e159b74d5f874ae4ea007a2dcaa18afbb0f00321"
