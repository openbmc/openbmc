require source-han-sans-fonts.inc

SUMMARY = "Adobe OpenType Pan-CJK font family for Japanese"
ZIPNAME = "SourceHanSansJP"

SRC_URI[sha256sum] = "1ae9f62ad620d686c4a049ce25cf54e3afd8fefc954a678c644cf9802750c17e"
