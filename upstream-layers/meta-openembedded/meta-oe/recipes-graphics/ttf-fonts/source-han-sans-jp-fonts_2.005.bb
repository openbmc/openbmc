require source-han-sans-fonts.inc

SUMMARY = "Adobe OpenType Pan-CJK font family for Japanese"
ZIPNAME = "17_SourceHanSansJP"

SRC_URI[sha256sum] = "076a167394a2bf125a7ab13164a5ea1ce529b988d867c11052e83473b2a704f1"
