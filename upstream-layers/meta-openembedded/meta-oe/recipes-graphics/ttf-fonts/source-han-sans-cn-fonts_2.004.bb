require source-han-sans-fonts.inc

SUMMARY = "Adobe OpenType Pan-CJK font family for Simplified Chinese"
ZIPNAME = "SourceHanSansCN"

SRC_URI[sha256sum] = "6841fc13f1c0d255cfeb33d2a2c68d24bbebd94ae2c070347a2b2b200a1db4d6"
