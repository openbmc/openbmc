require source-han-sans-fonts.inc

SUMMARY = "Adobe OpenType Pan-CJK font family for Korean"
ZIPNAME = "SourceHanSansKR"

SRC_URI[sha256sum] = "02fe28a48c6381c49d61c27a1b173c77f0e6f2b9f2b68e79f076f10a6a8f4bfe"
