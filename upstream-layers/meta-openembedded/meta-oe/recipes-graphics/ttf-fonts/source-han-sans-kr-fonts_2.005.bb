require source-han-sans-fonts.inc

SUMMARY = "Adobe OpenType Pan-CJK font family for Korean"
ZIPNAME = "18_SourceHanSansKR"

SRC_URI[sha256sum] = "ada0398122ebfebcae9efc1c6bb1dc5512c03b8f54035a8f527cd82a3c0441ac"
