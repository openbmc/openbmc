require xorg-data-common.inc

SUMMARY = "Common X11 Bitmaps"

LIC_FILES_CHKSUM = "file://COPYING;md5=91d7417ea327b03bd865e34bb3b6bc0e"

SRC_URI[sha256sum] = "895722f136e21e728c52f2d99fd2dae95018b9ddad1bac1f29d61bcd6593721d"
