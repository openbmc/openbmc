# helper class to prepare correct environment for native itstool

inherit python3native

DEPENDS:append = " itstool-native"
