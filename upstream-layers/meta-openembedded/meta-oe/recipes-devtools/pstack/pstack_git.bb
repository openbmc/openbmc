require pstack.inc

SRCREV = "1e1734be3adb6d9c81b57c5cc3d0c8fbc43bdee3"
PV = "2.11"

SRC_URI = "git://github.com/peadar/pstack.git;branch=master;protocol=https \
           file://0001-tests-fix-the-issue-of-cross-compilation-failure.patch \
          "
