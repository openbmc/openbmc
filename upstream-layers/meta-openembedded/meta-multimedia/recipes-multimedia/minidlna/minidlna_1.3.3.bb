require ${BPN}.inc

SRCREV = "1a9b32ee7a1c89e54e9f148199b73f9b33ad45ba"
LIC_FILES_CHKSUM = "file://LICENCE.miniupnpd;md5=b0dabf9d8e0f871554e309d62ead8d2b"
