SUMMARY = "This plugin makes it possible to take periodical breaks"
HOMEPAGE = "https://docs.xfce.org/panel-plugins/xfce4-time-out-plugin/start"
SECTION = "x11/application"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=59530bdf33659b29e73d4adb9f9f6552"

inherit xfce-panel-plugin

SRC_URI[sha256sum] = "b6b708900d7fd0cc3d8a045514962db94b60d959c266049aa2cff768fc381726"
