SUMMARY = "A calculator plugin for the Xfce panel"
HOMEPAGE = "https://docs.xfce.org/panel-plugins/xfce4-calculator-plugin/start"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=909430f63fddd63f120ba29e8979f65c"

inherit xfce-panel-plugin gtk-icon-cache

SRC_URI[sha256sum] = "3feb5f56092ceef2858c3c1bd443317d4caf289a6409f9db506f49088e19a2e8"
