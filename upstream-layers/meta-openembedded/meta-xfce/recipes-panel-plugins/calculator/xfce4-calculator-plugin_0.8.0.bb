SUMMARY = "A calculator plugin for the Xfce panel"
HOMEPAGE = "https://docs.xfce.org/panel-plugins/xfce4-calculator-plugin/start"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=909430f63fddd63f120ba29e8979f65c"

XFCE_COMPRESS_TYPE = "xz"

inherit xfce-panel-plugin gtk-icon-cache

SRC_URI[sha256sum] = "aaf3d7e9654ef6cf8ec442ad9e4316c481f9a6087a8e8949261140f5ae136aeb"
