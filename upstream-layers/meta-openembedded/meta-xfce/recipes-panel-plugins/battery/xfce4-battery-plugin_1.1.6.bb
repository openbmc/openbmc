SUMMARY = "A battery monitor panel plugin for Xfce4, compatible with APM and ACP"
HOMEPAGE = "https://docs.xfce.org/panel-plugins/xfce4-battery-plugin/start"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

inherit xfce-panel-plugin

SRC_URI[sha256sum] = "327d7304dded8411cd1a48da4f46bac248b44d8b27ffbc2036e0268cb37c3676"
