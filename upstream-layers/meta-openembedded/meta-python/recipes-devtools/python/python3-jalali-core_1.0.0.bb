DESCRIPTION = "A Gregorian to Jalali and inverse date convertor"
HOMEPAGE = "https://github.com/slashmili/jalali-core"
LICENSE = "LGPL-2.1-or-later"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a88966a0e5f4057719d2cc2766c6e091"

SRC_URI[sha256sum] = "f4287c70c630323dcf0a3ab26df905ba4d451e230ac1f65b3bb2f77797894a2b"

PYPI_PACKAGE = "jalali_core"

inherit pypi setuptools3
