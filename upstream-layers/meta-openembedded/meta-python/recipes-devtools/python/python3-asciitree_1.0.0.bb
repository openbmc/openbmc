SUMMARY = "ASCII trees"
DESCRIPTION = "Draws ASCII trees"
HOMEPAGE = "https://github.com/mbr/asciitree"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a533ab417405f77f9a3d236d35cd7069"

SRC_URI[sha256sum] = "0c396808c13cab27b60cbe402b99ef37fa681c6b59d337a008719efa201cdd07"

inherit pypi python_setuptools_build_meta
