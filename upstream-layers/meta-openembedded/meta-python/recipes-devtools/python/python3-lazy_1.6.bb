SUMMARY = "Lazy attributes are computed attributes that are evaluated only once, the first time they are used."

LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7df3865e8640604acfa474235d2db76b"

SRC_URI[sha256sum] = "7127324ec709e8324f08cb4611c1abe01776bda53bb9ce68dc5dfa46ca0ed3e9"

inherit pypi python_setuptools_build_meta
