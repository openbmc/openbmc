SUMMARY = "Unicode normalization forms (NFC, NFKC, NFD, NFKD). A library independent from the Python core Unicode database."
HOMEPAGE = "https://github.com/mlodewijck/pyunormalize"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1d882216fa7fde0aec58695aa05ef72f"

SRC_URI[sha256sum] = "0949a3e56817e287febcaf1b0cc4b5adf0bb107628d379335938040947eec792"

inherit pypi setuptools3
