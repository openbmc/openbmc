DESCRIPTION = "A library for parsing ISO 8601 strings."

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ba35a7f4192a3ea09a01f4e8169a56bc"

SRC_URI[sha256sum] = "25488f8663dd1528ae1f54f94ac1ea51ae25b4d531539b8bc707fed184d16845"

inherit pypi setuptools3
