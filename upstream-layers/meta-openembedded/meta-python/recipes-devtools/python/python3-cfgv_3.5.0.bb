SUMMARY = "Validate configuration and produce human readable error messages."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=92844452d544a48a78abc3a862fbd8a4"

PYPI_PACKAGE = "cfgv"

inherit pypi setuptools3
SRC_URI[sha256sum] = "d5b1034354820651caa73ede66a6294d6e95c1b00acc5e9b098e917404669132"
