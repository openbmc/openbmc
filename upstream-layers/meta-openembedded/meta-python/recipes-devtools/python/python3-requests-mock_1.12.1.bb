SUMMARY = "Mocked responses for the requests library"
HOMEPAGE = "https://github.com/jamielennox/requests-mock"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b2eea41aec0f2973a45e1e45f28aa32"

DEPENDS = "python3-setuptools-scm-native"
SRC_URI[sha256sum] = "e9e12e333b525156e82a3c852f22016b9158220d2f47454de9cae8a77d371401"

inherit pypi python_setuptools_build_meta
