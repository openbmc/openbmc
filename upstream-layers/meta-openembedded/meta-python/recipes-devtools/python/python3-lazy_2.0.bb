SUMMARY = "Lazy attributes are computed attributes that are evaluated only once, the first time they are used."

LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0ba506a1df3b54afc8b01c9964bb6bdb"

SRC_URI[sha256sum] = "f92ec0d32dd6bd115ddec4e3323473ebc0b682ad58c6aca78ebfd9e6d1aa5777"

inherit pypi python_setuptools_build_meta
