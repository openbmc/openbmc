SUMMARY = "Unicode normalization forms (NFC, NFKC, NFD, NFKD). A library independent from the Python core Unicode database."
HOMEPAGE = "https://github.com/mlodewijck/pyunormalize"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fcc278e239c8cbad362b2a7229f69b5c"

SRC_URI[sha256sum] = "2b2e65201e688bb38c66ab66ef1071cc07b32e9840e5ae07aab716db6ede7d6d"

inherit pypi python_setuptools_build_meta
