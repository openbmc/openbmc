DESCRIPTION = "HTTP/2 framing layer for Python"
HOMEPAGE = "https://github.com/python-hyper/hyperframe"
LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE;md5=5bf1c68e73fbaec2b1687b7e71514393"

SRC_URI[sha256sum] = "f630908a00854a7adeabd6382b43923a4c4cd4b821fcb527e6ab9e15382a3b08"

inherit pypi python_setuptools_build_meta
