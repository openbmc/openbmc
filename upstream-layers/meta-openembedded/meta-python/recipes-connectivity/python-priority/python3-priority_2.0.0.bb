DESCRIPTION = "A pure-Python implementation of the HTTP/2 priority tree"
HOMEPAGE = "https://github.com/python-hyper/priority"
LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE;md5=ae57d8a09fc8b6b164d7357339619045"

SRC_URI[sha256sum] = "c965d54f1b8d0d0b19479db3924c7c36cf672dbf2aec92d43fbdaf4492ba18c0"

inherit pypi setuptools3
