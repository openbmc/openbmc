require meta-filesystems-image-ptest-all.bb

DESCRIPTION = "Recipe to trigger execution of all fast meta-filesystems ptest images."

PTESTS_META_FILESYSTEMS = "${PTESTS_FAST_META_FILESYSTEMS}"
