require mctp.inc

SUMMARY = "Management Component Transport Protocol (MCTP) utilities"

MESON_TARGET = "mctp mctp-client"
