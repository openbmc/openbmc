require mctp.inc

SUMMARY = "Management Component Transport Protocol (MCTP) utilities"

MESON_TARGET = "mctp mctp-client"
MESON_INSTALL_TAGS += "utils"
