require meta-networking-image-ptest-all.bb

DESCRIPTION = "Recipe to trigger execution of all fast meta-networking ptest images."

PTESTS_META_NETWORKING = "${PTESTS_FAST_META_NETWORKING}"
