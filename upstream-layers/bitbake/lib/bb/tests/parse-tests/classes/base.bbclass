# At least one task is required for bitbake to parse
do_fetch() {
    :
}
addtask do_fetch
