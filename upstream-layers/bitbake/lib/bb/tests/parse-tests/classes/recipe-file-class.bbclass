BBCLASS_RECIPE_FILE := "${@os.path.basename(d.getVar('__BB_RECIPE_FILE'))}"
BBCLASS_FILE := "${@os.path.basename(d.getVar('FILE'))}"
