FILESEXTRAPATHS_prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://ethanolx.cfg \
            file://0001-ARM-dts-aspeed-Add-GPIO-line-names-for-AMD-EthanolX.patch"
