PACKAGECONFIG_ethanolx = "\
    hwmontempsensor \
    fansensor \
    psusensor \
    adcsensor \
    "
