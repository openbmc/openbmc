FILESEXTRAPATHS:prepend:ethanolx := "${THISDIR}/${BPN}:"
