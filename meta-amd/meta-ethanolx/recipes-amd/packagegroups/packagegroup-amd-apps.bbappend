RDEPENDS:${PN}-system:append:ethanolx = " ip-to-fpga"
