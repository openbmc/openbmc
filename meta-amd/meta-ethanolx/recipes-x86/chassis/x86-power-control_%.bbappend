FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Amd-power-control-modifications-for-EthanolX.patch"
