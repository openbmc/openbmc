PACKAGECONFIG:append = " log-threshold log-pulse"
