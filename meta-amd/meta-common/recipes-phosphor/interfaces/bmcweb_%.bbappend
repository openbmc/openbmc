EXTRA_OEMESON:append = " \
    -Dhttp-body-limit=128 \
"

PACKAGECONFIG:append = "redfish-dbus-log"
