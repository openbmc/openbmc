PACKAGECONFIG_append = " log-threshold log-pulse"
