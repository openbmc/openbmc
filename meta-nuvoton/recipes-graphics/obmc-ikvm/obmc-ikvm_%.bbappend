LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"
SRC_URI:nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm.git;branch=master;protocol=https"
SRCREV:nuvoton := "40f879557d7fe612a6dac6dbc0d1dbdca1eacfc5"

#LIC_FILES_CHKSUM = "file://LICENSE;md5=75859989545e37968a99b631ef42722e"
#SRC_URI:nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm.git;branch=upstream;protocol=https"
#SRCREV:nuvoton := "e7ae01193609dd86ef982a4641fefa2cc8af8f12"
