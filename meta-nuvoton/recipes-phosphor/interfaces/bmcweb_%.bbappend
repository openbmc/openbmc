FILESEXTRAPATHS:append:nuvoton := ":${THISDIR}/${PN}"

SRC_URI:append:nuvoton = " file://0001-Fix-WS-connection-failed.patch"
