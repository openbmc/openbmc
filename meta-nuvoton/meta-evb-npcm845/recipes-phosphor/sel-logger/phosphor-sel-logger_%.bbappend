PACKAGECONFIG:append = " log-threshold log-alarm log-watchdog send-to-logger"
