PACKAGECONFIG = " \
    hwmontempsensor \
    fansensor \
    adcsensor \
    "
