EXTRA_OECONF:class-native:append = " no-module"
