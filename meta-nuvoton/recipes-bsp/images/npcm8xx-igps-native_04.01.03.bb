# tag IGPS_04.01.03
SRCREV = "ae5ddb6c8ff350835d411b9e3bfb4443db596067"

require npcm8xx-igps.inc
