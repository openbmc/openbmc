# tag IGPS_03.09.03
SRCREV = "32997b388992458b0fb55104be79328dc792b140"

require npcm8xx-igps.inc
