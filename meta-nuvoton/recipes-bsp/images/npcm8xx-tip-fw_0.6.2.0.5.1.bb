SRCREV = "abcf1e2f4dfb0431cd74497925eb3e25dfbdba70"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
