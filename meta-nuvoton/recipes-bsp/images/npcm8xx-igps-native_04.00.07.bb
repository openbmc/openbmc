# tag IGPS_04.00.07
SRCREV = "d1a2b585de580028a74fda4b90729cc5192bc28f"

require npcm8xx-igps.inc
