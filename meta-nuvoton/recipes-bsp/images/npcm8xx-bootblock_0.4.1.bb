SRCREV = "a5763b9b6ec8f4f171f9c4a1c50d662e53037497"

require npcm8xx-bootblock.inc
