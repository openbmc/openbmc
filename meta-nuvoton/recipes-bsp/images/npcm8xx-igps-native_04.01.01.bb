# tag IGPS_04.01.01
SRCREV = "e40802335270a2af6744d9160c7eae15b5777217"

require npcm8xx-igps.inc
