# base on IGPS_03.07.09 with export sign image function for openbmc
SRCREV = "baf70719d0e10ffbf8b3d5614e6f96e072e9ef8a"

require npcm8xx-igps.inc
