SRCREV = "4a12209ba483f511a7bf5090ca5d3872e82299eb"

require npcm8xx-bootblock.inc
