SRCREV = "4d8c0b36cdb6bdd227a6e5a7a0f53cd16c141de3"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
