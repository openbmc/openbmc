# this recipe is only intended for specific users, so don't choose it by default
DEFAULT_PREFERENCE = "-1"

# tag IGPS_03.07.02_Google
SRCREV = "d19d7e2a75c6aa35e745fe5e00bf7b256df11278"
IGPS_BRANCH = "igps_npcm8xx_google"

require npcm8xx-igps.inc
