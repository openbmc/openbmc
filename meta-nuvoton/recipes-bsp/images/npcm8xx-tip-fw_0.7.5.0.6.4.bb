SRCREV = "6a4c6119a60bd7af259a32c36196e70a7ee61661"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
