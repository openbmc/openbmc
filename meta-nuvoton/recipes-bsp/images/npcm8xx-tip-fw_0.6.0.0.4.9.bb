SRCREV = "26d7677ddf1068f697e570f45bae7f51041cb2f1"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
