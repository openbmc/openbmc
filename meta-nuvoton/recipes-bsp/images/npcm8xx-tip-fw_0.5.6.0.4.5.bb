SRCREV = "e77ac50935dc20e042ac96f932ae2629d655b068"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
