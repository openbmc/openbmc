SRCREV = "a01f053b639e6665c392e720eeab73edabe0d8d9"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
