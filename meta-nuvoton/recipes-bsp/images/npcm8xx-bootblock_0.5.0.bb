SRCREV = "1500d172005fe379d5ae5a04c412d39c4ac58405"

require npcm8xx-bootblock.inc
