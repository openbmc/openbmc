# tag IGPS_03.08.03
SRCREV = "d8d053baa4c20657877343b9afcb6e21ae5849ac"

require npcm8xx-igps.inc
