# tag IGPS_03.08.06
SRCREV = "96bba1f416dfc206be6d0cd9f224446cf21fd7a0"

require npcm8xx-igps.inc
