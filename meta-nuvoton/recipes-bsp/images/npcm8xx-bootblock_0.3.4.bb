SRCREV = "3c8eb05241ea16199d861f8cfbf2d2eca1bb48b2"

require npcm8xx-bootblock.inc
