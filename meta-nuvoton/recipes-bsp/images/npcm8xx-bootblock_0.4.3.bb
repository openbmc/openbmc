SRCREV = "d300c35173a733a4cfa2f877477d5e72f9c3b538"

require npcm8xx-bootblock.inc
