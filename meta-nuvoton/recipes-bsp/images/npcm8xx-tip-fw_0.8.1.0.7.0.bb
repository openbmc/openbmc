SRCREV = "2321cc482a0ea499c7edef9e5babbc804febc378"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
