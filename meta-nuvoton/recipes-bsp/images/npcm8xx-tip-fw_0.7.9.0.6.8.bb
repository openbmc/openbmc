SRCREV = "353e574b63763cf3fe48caba374013808f2adc29"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
