SRCREV = "0f7e299e0ab4153cd7ecdb511c1afd95c67fee47"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
