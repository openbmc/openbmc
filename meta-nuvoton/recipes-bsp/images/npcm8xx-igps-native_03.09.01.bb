# tag IGPS_03.09.01
SRCREV = "2053299fad5ab24e6df054c304d13f877bee67b6"

require npcm8xx-igps.inc
