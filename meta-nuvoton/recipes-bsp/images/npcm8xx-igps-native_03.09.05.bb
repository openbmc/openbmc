# tag IGPS_03.09.05
SRCREV = "a6ba5ac55619fa3babe658da4eb811b4c1c1ea25"

require npcm8xx-igps.inc
