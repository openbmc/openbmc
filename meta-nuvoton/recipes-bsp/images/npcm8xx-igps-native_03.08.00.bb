# tag IGPS_03.08.00
SRCREV = "69c2f8bc0ed599a8148400f24f8217e1fd44f001"

require npcm8xx-igps.inc
