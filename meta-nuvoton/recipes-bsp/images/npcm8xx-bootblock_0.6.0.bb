SRCREV = "1610c1be31044bfb1f4afae8d7ac143aae2c2fe7"

require npcm8xx-bootblock.inc
