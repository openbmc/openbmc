SRCREV = "800b4fe1cec1b04681ab4367afa4b0c9300d43d5"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
