SRCREV = "4478e7a4d36afd33c7aab6b139e386a1dd5f5a2d"

require npcm8xx-bootblock.inc
