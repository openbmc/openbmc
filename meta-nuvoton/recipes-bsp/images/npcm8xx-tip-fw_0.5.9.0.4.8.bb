SRCREV = "1429f76f2cb4fb073693cbf9e696d9f61d02c509"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
