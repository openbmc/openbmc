SRCREV = "e5d886049b1b06c61a6df792c8f4617c572abce1"

require npcm8xx-bootblock.inc
