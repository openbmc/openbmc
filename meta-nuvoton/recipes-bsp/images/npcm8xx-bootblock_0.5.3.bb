SRCREV = "c687945cf573c2d9f8f061c1a7c72eb188a60798"

require npcm8xx-bootblock.inc
