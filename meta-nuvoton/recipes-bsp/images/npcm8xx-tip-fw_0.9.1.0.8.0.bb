SRCREV = "fa65dd885a19393a8902b421ff9c4fc8ecfca3f7"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
