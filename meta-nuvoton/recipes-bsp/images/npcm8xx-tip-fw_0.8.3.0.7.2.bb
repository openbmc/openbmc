SRCREV = "dc619a0714890d6ccfa22afe4394e7d6a9bd0ccc"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
