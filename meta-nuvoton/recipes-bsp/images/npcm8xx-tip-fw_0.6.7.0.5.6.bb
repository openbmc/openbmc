SRCREV = "65c421f6bd7efb96c1d95fcaaf13425129fba2c0"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
