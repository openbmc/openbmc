SRCREV = "e65f9acef6d915aa6a36d6889b890ff07e5bd606"

require npcm8xx-bootblock.inc
