SRCREV = "c0418a3e5df233bb9c69b805c60d606fa3066654"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
