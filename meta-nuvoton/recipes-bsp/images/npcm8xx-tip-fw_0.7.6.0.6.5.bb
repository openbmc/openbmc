SRCREV = "e269890c3b54029371360c9879bf5f17dcba3b2b"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
