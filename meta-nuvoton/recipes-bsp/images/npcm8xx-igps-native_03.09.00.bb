# tag IGPS_03.09.00
SRCREV = "30086cd06bee63c5715622a624620c30ade6652e"

require npcm8xx-igps.inc
