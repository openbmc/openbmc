SRCREV = "78d98c20af250b7ed2345e5486e9bedfe0527cc5"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
