SRCREV = "b45a45bce6e557af49b43492904579edb5f084a3"

require npcm8xx-bootblock.inc
