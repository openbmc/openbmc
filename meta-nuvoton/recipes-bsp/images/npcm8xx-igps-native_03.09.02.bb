# tag IGPS_03.09.02
SRCREV = "c087fcc14a67ae912a51d6fd90c3daa27560d8bc"

require npcm8xx-igps.inc
