# tag IGPS_03.09.07
SRCREV = "09b1162fef7783b6e681905f6a4ddb4c3ceb3694"

require npcm8xx-igps.inc
