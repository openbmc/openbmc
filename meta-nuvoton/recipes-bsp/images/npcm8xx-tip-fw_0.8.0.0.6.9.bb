SRCREV = "50ef0503b874f6d2732bd541a84d9dcf67ddde0a"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
