SRCREV = "594b67c9b2c72cc83415d4deca55dcc8f0aeb09a"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
