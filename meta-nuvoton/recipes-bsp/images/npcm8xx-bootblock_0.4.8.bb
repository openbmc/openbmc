SRCREV = "e18737d17d4cf5e7768598a291a7ef2b8a07a776"

require npcm8xx-bootblock.inc
