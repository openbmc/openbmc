SRCREV = "344214ea18d884e0ba4c0fc21fa732858386d351"

require npcm8xx-bootblock.inc
