SRCREV = "bdbfc0324150c4471c77bafc2cf5f6f3c64cf814"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
