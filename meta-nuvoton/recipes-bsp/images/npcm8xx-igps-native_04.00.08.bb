# tag IGPS_04.00.08
SRCREV = "7e009f77dcc5b4cde80f1ba47b1cf5a010d7e197"

require npcm8xx-igps.inc
