# tag IGPS_03.09.08
SRCREV = "aeeda7d627744e79d1a66862476896dda57e614a"

require npcm8xx-igps.inc
