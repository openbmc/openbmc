SRCREV = "49c4ddb7feed3653dde1c77e235e41e42c3e73e5"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
