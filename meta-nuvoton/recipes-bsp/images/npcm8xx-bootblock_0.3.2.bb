SRCREV = "4a0758cf7c2ea1505e648346a7a407c3974467a7"

require npcm8xx-bootblock.inc
