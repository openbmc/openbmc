# tag IGPS_04.00.06
SRCREV = "748e89d30787ba359464be11b6aecae4cb00b204"

require npcm8xx-igps.inc
