SRCREV = "fd591f0b10a3d1ebc5eaf592f43eb8ce90ca7ae2"

require npcm8xx-bootblock.inc
