SRCREV = "bc1b9c304490e54553f2d449fa2e9950a6f9e4ae"

require npcm8xx-bootblock.inc
