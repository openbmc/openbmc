SRCREV = "20ed3835913a05ae335aff83c11ecc85c84f0cbc"

require npcm8xx-bootblock.inc
