SRCREV = "cf3ae603b6b2fd2e44b446105976e69f4a112c52"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
