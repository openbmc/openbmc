SRCREV = "06b91b7b7108e794b0fd1ea2f96d7affc61a3cf9"

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
