SRCREV = "4002b2f086f6d2177ec36bed507241386d604f6b"
RELEASE = "A35_BootBlock_0.2.8"

SRC_URI[bin.sha256sum] = "164c5e57d02accd61c14b6e13dff3dbbbe1d64375ca6ee97da50b9850dfb7f49"

require npcm8xx-bootblock.inc
