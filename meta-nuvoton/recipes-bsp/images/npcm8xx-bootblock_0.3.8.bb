SRCREV = "282a8a1f0af17bbb517d31e846c0626c42b9673c"

require npcm8xx-bootblock.inc
