## meta-nxp/conf/machine/include/imx93.inc
```bitbake
# SPDX-License-Identifier: Apache-2.0

MACHINEOVERRIDES =. "mx93:"

require conf/machine/include/arm/armv8-2a/tune-cortexa55.inc
```
