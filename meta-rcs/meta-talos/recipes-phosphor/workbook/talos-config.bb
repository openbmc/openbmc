SUMMARY = "Talos II board wiring"
DESCRIPTION = "Talos II wiring information for the Talos II OpenPOWER system."
PR = "r1"

inherit config-in-skeleton
