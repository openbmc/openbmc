RDEPENDS_${PN} += 'avsbus-control'
RDEPENDS_${PN} += 'vrm-control'
