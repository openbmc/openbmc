FILESEXTRAPATHS_prepend_talos := "${THISDIR}/${PN}:"
