FILESEXTRAPATHS:prepend:kudo := "${THISDIR}/linux-nuvoton:"

SRC_URI:append:kudo = " file://kudo.cfg"
