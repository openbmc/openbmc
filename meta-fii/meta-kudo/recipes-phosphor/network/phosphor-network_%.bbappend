PACKAGECONFIG:append:kudo = " nic-ethtool"
