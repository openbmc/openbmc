FILESEXTRAPATHS:append:kudo := ":${THISDIR}/${BPN}"
SRC_URI:append:kudo = " file://gpio_defs.json"

