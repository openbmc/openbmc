PACKAGECONFIG_append_kudo = " nuvoton-p2a-mbox net-bridge"

IPMI_FLASH_BMC_ADDRESS_kudo = "0xF0848000"
