FILESEXTRAPATHS:append:kudo := ":${THISDIR}/${BPN}"
SRC_URI:append:kudo = " file://chassis_capabilities.override.yml"
