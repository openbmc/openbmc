EXTRA_OEMESON_append_kudo = " \
    -Dredfish-dump-log=enabled \
    -Dredfish-bmc-journal=enabled \
    -Dredfish-allow-deprecated-hostname-patch=enabled \
"
