# Kudo doesn't use bmcweb

PACKAGES:remove:kudo = "\
        ${PN}-bmcweb \
        "
