PACKAGECONFIG:append:kudo = " smbios-ipmi-blob"
