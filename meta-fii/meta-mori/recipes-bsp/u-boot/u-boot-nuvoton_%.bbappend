FILESEXTRAPATHS:prepend:mori := "${THISDIR}/${BPN}:"

SRC_URI:append:mori = " file://mori.cfg"
