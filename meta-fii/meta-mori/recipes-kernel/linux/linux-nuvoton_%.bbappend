FILESEXTRAPATHS:prepend:mori := "${THISDIR}/linux-nuvoton:"

SRC_URI:append:mori = " file://mori.cfg \
                      "

