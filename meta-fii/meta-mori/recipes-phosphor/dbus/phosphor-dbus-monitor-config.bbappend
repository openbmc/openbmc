PHOSPHOR_DBUS_MONITOR_CONFIGS:append:mori = " led-policy-mori"
