PACKAGECONFIG:append = " \
    redfish-dump-log \
"
