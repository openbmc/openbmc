PACKAGECONFIG:append:mori = " nic-ethtool"
