PACKAGECONFIG:append:mori = " smbios-ipmi-blob"
