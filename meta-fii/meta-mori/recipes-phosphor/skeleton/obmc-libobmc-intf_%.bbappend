FILESEXTRAPATHS:append:mori := ":${THISDIR}/${BPN}"

SRC_URI:append:mori = " file://gpio_defs.json"
