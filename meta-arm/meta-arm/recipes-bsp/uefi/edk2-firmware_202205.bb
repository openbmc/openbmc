SRCREV_edk2           ?= "16779ede2d366bfc6b702e817356ccf43425bcc8"
SRCREV_edk2-platforms ?= "3b896d1a325686de3942723c42f286090453e37a"

require edk2-firmware.inc
