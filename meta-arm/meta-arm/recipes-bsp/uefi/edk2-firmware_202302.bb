SRCREV_edk2           ?= "f80f052277c88a67c55e107b550f504eeea947d3"
SRCREV_edk2-platforms ?= "65e001a7f2abedf7799cfb36b057326c1540bd47"

require edk2-firmware.inc
