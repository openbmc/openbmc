require recipes-bsp/trusted-firmware-m/trusted-firmware-m-1.8.0-src.inc
require recipes-bsp/trusted-firmware-m/trusted-firmware-m.inc
