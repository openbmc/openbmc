require recipes-bsp/trusted-firmware-m/trusted-firmware-m-1.7.0-src.inc
require recipes-bsp/trusted-firmware-m/trusted-firmware-m-scripts-native.inc
