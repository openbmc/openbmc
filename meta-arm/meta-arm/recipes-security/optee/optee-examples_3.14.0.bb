require optee-examples.inc

SRCREV = "e9c870525af8f7e7fccf575a0ca5394ce55adcec"

