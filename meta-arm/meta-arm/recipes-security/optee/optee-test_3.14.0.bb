require optee-test.inc

SRCREV = "f2eb88affbb7f028561b4fd5cbd049d5d704f741"
