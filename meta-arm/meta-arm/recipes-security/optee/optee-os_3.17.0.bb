require optee-os.inc

SRCREV = "f9e550142dd4b33ee1112f5dd64ffa94ba79cefa"

DEPENDS += "dtc-native"
