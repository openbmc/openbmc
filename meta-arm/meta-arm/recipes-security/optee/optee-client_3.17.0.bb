require optee-client.inc

SRCREV = "9a337049c52495e5e16b4a94decaa3e58fce793e"
