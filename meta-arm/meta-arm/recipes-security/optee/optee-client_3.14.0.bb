require optee-client.inc

SRCREV = "06e1b32f6a7028e039c625b07cfc25fda0c17d53"
