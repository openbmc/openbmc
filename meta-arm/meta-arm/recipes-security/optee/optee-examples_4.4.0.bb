require recipes-security/optee/optee-examples.inc

# v4.4.0
SRCREV = "378dc0db2d5dd279f58a3b6cb3f78ffd6b165035"
