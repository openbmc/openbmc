require optee-client.inc

SRCREV = "e7cba71cc6e2ecd02f412c7e9ee104f0a5dffc6f"
