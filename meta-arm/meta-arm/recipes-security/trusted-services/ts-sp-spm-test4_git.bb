DESCRIPTION = "Trusted Services SPMC test SP4"

SP_INDEX="4"

require ts-sp-spm-test-common.inc

