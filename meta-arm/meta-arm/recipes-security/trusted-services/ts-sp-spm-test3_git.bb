DESCRIPTION = "Trusted Services SPMC test SP3"

SP_INDEX="3"

require ts-sp-spm-test-common.inc

