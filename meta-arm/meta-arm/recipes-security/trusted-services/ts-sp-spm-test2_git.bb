DESCRIPTION = "Trusted Services SPMC test SP2"

SP_INDEX = "2"

require ts-sp-spm-test-common.inc

