DESCRIPTION = "Trusted Services SPMC test SP1"

SP_INDEX="1"

require ts-sp-spm-test-common.inc
