# Update MM communication buffer address for qemuarm64 machine
SRC_URI:append:qemuarm64-secureboot = "file://0001-QEMU-MM-communication-buffer-address.patch \
"
