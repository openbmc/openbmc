include arm-systemready-scripts-native-${MACHINE}.inc
