include arm-systemready-ir-acs-${MACHINE}.inc
