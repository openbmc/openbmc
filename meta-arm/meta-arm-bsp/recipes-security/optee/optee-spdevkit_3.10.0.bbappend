# Machine specific configurations

MACHINE_OPTEE_SPDEVKIT_REQUIRE ?= ""

require ${MACHINE_OPTEE_SPDEVKIT_REQUIRE}
