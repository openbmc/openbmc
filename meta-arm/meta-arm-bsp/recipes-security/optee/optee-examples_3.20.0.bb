require recipes-security/optee/optee-examples.inc

SRCREV = "a98d01e1b9168eaed96bcd0bac0df67c44a81081"
