require recipes-security/optee/optee-examples.inc

SRCREV = "f301ee9df2129c0db683e726c91dc2cefe4cdb65"
