require recipes-security/optee/optee-os.inc

SRCREV = "d1c635434c55b7d75eadf471bde04926bd1e50a7"
