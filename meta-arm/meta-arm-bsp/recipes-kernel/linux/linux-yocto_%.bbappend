# Add support for Arm Platforms (boards or simulators)

require linux-arm-platforms.inc
