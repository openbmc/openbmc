# Machine specific configurations

FILESEXTRAPATHS:prepend := "${THISDIR}/${BP}:"

require linux-arm-platforms.inc
