# Machine specific TFAs

COMPATIBLE_MACHINE:corstone1000 = "corstone1000"
