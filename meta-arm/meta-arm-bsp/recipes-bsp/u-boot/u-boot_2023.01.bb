require recipes-bsp/u-boot/u-boot-common.inc
require recipes-bsp/u-boot/u-boot.inc

SRCREV = "62e2ad1ceafbfdf2c44d3dc1b6efc81e768a96b9"
