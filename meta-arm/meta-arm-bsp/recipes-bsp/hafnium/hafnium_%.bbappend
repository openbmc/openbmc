# Machine specific configurations

MACHINE_HAFNIUM_REQUIRE ?= ""
MACHINE_HAFNIUM_REQUIRE:tc = "hafnium-tc.inc"

require ${MACHINE_HAFNIUM_REQUIRE}
