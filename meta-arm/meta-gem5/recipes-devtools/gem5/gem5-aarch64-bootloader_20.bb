# gem5 custom bootloader

require gem5-source_20.inc

BPN = "gem5-aarch64-bootloader"

require gem5-aarch64-bootloader.inc
