require recipes-phosphor/images/nvidia-phosphor-image.inc

# Please do not add any content directly to this file.  Instead add it to
# the corresponding .inc file.
