EXTRA_OEMESON:append = " \
    -Dinsecure-enable-redfish-query=enabled \
    -Dhttp-body-limit=200 \
"
