EXTRA_OEMESON:append:nv-gpu-pcie-card = " -Dinit-p2020=enabled"
