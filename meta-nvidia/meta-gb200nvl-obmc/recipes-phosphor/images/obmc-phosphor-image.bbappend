require recipes-phosphor/images/nvidia-gb200-obmc-phosphor-image.inc

# Please do not add any content directly to this file.  Instead add it to
# the corresponding .inc file.
