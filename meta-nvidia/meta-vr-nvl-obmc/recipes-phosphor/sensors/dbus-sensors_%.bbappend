PACKAGECONFIG:append = " nvidia-gpu"
