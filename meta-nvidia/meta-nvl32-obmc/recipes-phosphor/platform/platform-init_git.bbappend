FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

EXTRA_OEMESON:append = "-Dplatform-name=nvidia-nvl32"
