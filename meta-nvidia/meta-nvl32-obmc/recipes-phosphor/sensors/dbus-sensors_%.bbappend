PACKAGECONFIG:append = " \
    nvidia-gpu \
"
