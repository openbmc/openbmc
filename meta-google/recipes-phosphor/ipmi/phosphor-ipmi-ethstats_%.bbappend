# Enable registration via Google OEM Number in addition to OpenBMC.
EXTRA_OECONF:append = " --enable-google"
