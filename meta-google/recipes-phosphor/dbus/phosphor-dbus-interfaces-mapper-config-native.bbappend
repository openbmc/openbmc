PHOSPHOR_MAPPER_SERVICE_append = " com.google.gbmc"
PHOSPHOR_MAPPER_INTERFACE_append = " com.google.gbmc"
