EXTRA_OEMESON:append:gbmc = " \
  -Dupdate-functional-on-fail=true \
  -Dnegative-errno-on-fail=false \
"
