# Enable google domain for gBMC
EXTRA_OEMESON:append:gbmc = " \
   -Dgoogle-api=enabled \
"