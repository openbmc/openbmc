FILESEXTRAPATHS:prepend:gbmc := "${THISDIR}/${BPN}:"
