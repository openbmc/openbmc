# Remove unneeded gnupg help files to save space
EXTRA_OECONF:append:gbmc = " --disable-doc"
