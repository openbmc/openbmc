PACKAGECONFIG:remove = "libidn"
