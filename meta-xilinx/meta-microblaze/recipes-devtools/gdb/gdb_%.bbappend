MICROBLAZEPATCHES = ""
MICROBLAZEPATCHES_microblaze = "gdb-microblaze.inc"

require ${MICROBLAZEPATCHES}
