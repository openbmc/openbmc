require gcc-configure-xilinx-standalone.inc
require gcc-xilinx-standalone.inc

# We want to use the stock multilib configs, when available
EXTRACONFFUNCS_xilinx-standalone = ""

