inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xilplmi/src/"
ESW_COMPONENT_NAME = "libxilplmi.a"

DEPENDS += "xilstandalone libxil"
