inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xilmailbox/src/"
ESW_COMPONENT_NAME = "libxilmailbox.a"

DEPENDS += "xilstandalone libxil"
