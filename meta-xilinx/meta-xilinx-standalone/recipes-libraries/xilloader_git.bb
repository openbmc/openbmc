inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xilloader/src/"
ESW_COMPONENT_NAME = "libxilloader.a"

DEPENDS += "xilstandalone libxil xilpm xilpdi xilffs xilsecure xilpuf"
