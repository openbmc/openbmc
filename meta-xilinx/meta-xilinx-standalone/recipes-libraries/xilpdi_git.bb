inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xilpdi/src/"
ESW_COMPONENT_NAME = "libxilpdi.a"

DEPENDS += "xilstandalone libxil"
