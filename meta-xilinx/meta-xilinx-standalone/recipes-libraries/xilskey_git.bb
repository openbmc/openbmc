inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xilskey/src/"
ESW_COMPONENT_NAME = "libxilskey.a"

DEPENDS += "libxil"
