inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xilsem/src/"
ESW_COMPONENT_NAME = "libxilsem.a"

DEPENDS += "xilstandalone libxil"
