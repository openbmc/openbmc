inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xilmem/src/"
ESW_COMPONENT_NAME = "libxilmem.a"

DEPENDS += "xilstandalone"
