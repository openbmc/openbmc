inherit esw_examples

ESW_COMPONENT_SRC = "/XilinxProcessorIPLib/drivers/ttcps/examples/"
