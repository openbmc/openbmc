require qemu-devicetrees.inc

BRANCH ?= "branch/xilinx-v2020.2"
SRCREV ?= "0097f0f651d67b3a8495693e9e17c443948d3c77"
