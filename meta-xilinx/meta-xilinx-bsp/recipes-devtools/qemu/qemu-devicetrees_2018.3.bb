require qemu-devicetrees.inc

XILINX_RELEASE_VERSION = "v2018.3"

BRANCH ?= "master"
SRCREV ?= "e3e40b8829894a479c7d7380fc8137886645dda8"
