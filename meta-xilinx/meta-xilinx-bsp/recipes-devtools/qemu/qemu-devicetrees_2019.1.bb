require qemu-devicetrees.inc

XILINX_RELEASE_VERSION = "v2019.1"

BRANCH ?= "branch/xilinx-v2019.1"
SRCREV ?= "445406ef4d06303f00387f7d81e8718255336fd0"
