require qemu-xilinx.inc

XILINX_RELEASE_VERSION = "v2019.1"
XILINX_QEMU_VERSION ?= "v2.11.1"
BRANCH ?= "branch/xilinx-v2019.1"
SRCREV ?= "5f38ea92fb697b94ad43f01fe162f3ed6e6b0e16"
