require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "${AUTOREV}"
