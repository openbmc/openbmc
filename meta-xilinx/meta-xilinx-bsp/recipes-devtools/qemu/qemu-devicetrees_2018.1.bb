require qemu-devicetrees.inc

XILINX_RELEASE_VERSION = "v2018.1"

BRANCH ?= "master"
SRCREV ?= "d5017f8119b6493d8b2fcdfd5caa4e8b16580877"
