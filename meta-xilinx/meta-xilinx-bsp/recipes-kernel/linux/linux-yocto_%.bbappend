require linux-yocto-xilinx.inc
