LINUX_VERSION = "4.19"
XILINX_RELEASE_VERSION = "v2019.1"
KBRANCH ?= "xlnx_rebase_v4.19"
SRCREV ?= "9811303824b66a8db9a8ec61b570879336a9fde5"

include linux-xlnx.inc

