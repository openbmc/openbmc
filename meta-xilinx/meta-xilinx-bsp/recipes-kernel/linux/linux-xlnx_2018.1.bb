LINUX_VERSION = "4.14"
XILINX_RELEASE_VERSION = "v2018.1"
KBRANCH ?= "xlnx_rebase_v4.14"
SRCREV ?= "4ac76ffacb54712b0361e51d0b7156e53d062e3c"

include linux-xlnx.inc

