DEPENDS_append_zynqmp =  " virtual/libgles2"
