do_install_append_zynqmp () {
    rm -rf ${D}${includedir}/KHR/*
}
