MICROBLAZEPATCHES = ""
MICROBLAZEPATCHES_microblaze = "binutils-microblaze.inc"

require ${MICROBLAZEPATCHES}
