require recipes-devtools/gdb/gdb-common.inc
require recipes-devtools/gdb/gdb-cross-canadian.inc
require gdb-${PV}.inc
require gdb-microblaze-7.7.inc
