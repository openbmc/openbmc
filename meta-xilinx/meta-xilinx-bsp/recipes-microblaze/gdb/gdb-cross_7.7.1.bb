require recipes-devtools/gdb/gdb-cross.inc
require gdb-${PV}.inc
require gdb-microblaze-7.7.inc
