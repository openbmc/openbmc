ATF_VERSION = "2.0"
BRANCH ?= "xlnx_rebase_v2.2"
SRCREV ?= "e6eea88b14aaf456c49f9c7e6747584224648cb9"

include arm-trusted-firmware.inc

