ATF_VERSION = "1.5"
XILINX_RELEASE_VERSION = "v2018.3"
BRANCH ?= "master"
SRCREV ?= "08560c36ea5b6f48b962cb4bd9a79b35bb3d95ce"

include arm-trusted-firmware.inc

