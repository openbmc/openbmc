ATF_VERSION = "1.4"
XILINX_RELEASE_VERSION = "v2018.1"
BRANCH ?= "master"
SRCREV ?= "df4a7e97d57494c7d79de51b1e0e450d982cea98"

include arm-trusted-firmware.inc

