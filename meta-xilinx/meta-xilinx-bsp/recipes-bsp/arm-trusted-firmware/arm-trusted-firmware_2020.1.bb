ATF_VERSION = "2.0"
BRANCH ?= "xlnx_rebase_v2.2"
SRCREV ?= "5918e656ef29dbdf234a6324ec85bc8a68eca113"

include arm-trusted-firmware.inc

