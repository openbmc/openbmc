ALLOW_EMPTY_${PN} = "1"
