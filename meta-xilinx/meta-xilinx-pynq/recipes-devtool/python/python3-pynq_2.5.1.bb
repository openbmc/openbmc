inherit pypi setuptools3
require python-pynq.inc

