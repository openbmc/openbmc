FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI =+ "file://0001-4-byte-read-support-466.patch"
