FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-boost-Always-sort-shared-before-static-fixes-7171.patch"
