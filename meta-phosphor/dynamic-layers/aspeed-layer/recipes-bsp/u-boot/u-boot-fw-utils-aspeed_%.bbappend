FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

require u-boot-aspeed.inc
