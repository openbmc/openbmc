ASPEED_IMAGE_SIZE_KB = "${FLASH_SIZE}"
