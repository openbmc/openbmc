require recipes-bsp/u-boot/u-boot-obmc.inc
