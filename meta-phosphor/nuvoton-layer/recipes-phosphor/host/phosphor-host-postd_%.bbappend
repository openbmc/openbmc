FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SNOOP_DEVICE = "npcm7xx-lpc-bpc0"
