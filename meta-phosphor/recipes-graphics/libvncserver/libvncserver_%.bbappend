PACKAGECONFIG_append = " openssl"
PACKAGECONFIG_remove = "gcrypt gnutls png sdl"
