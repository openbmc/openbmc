# Fix https://github.com/systemd/systemd/issues/21113
SRC_URI += "file://0001-conf-parse-make-config_parse_many-optionally-save-st.patch"
