RDEPENDS:${PN}:remove = " \
              lttng-tools \
              lttng-ust \
              lttng-modules \
              powertop \
              latencytop \
              "
