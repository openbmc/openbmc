RDEPENDS_${PN}_append = " \
        nativesdk-autoconf-archive \
        nativesdk-meson \
        nativesdk-phosphor-dbus-interfaces-yaml \
        nativesdk-python3-sdbus++ \
        nativesdk-phosphor-logging-elog \
        "
