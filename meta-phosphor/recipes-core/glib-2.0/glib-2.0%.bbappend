## We do not currently use any gio-modules, set clear this variable to prevent
## the postinstall hook from being done.  The postinstall hook prevents
## the read-only-rootfs IMAGE_FEATURE.
GIO_MODULE_PACKAGES = ""
