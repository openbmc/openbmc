DEPENDS += "phosphor-software-manager-error-native"
