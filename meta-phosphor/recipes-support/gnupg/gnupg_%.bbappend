# Remove unneeded gnupg help files to save space
EXTRA_OECONF:append:openbmc-phosphor = " --disable-doc"
