EXTRA_OECMAKE:append:openbmc-phosphor = "-DBOOST_URL_STANDALONE=ON"
