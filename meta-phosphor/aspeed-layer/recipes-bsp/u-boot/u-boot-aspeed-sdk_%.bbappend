FLASH_SIZE ?= "32768"
ASPEED_IMAGE_SIZE_KB = "${FLASH_SIZE}"
