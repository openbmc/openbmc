FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

require u-boot-aspeed.inc
