FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

require u-boot-aspeed.inc
require recipes-bsp/u-boot/u-boot-obmc.inc
