# Common code for recipes that implement Phosphor OpenBMC filesystem

RPROVIDES_${PN} += "obmc-phosphor-initfs"
PROVIDES += "obmc-phosphor-initfs"
