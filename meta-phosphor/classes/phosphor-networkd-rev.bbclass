SRC_URI += "git://github.com/openbmc/phosphor-networkd"
SRCREV = "e8d42112b94dbb8fb90cc90443cf99673935d2ae"
