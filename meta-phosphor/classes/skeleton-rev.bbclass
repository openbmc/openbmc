SRCREV ?= "12fcf10886c5f75828f34f13d945ef29f59cb814"
SKELETON_URI ?= "git://github.com/openbmc/skeleton;branch=master;protocol=https"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://../LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e"
