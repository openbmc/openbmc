obmc_root="/xyz/openbmc_project"
obmc_inventory_root="${obmc_root}/Inventory"
obmc_sensors_root="${obmc_root}/sensors"
obmc_leds_root="${obmc_root}/led"
obmc_state_root="${obmc_root}/state"

obmc_mapper_path="${obmc_root}/ObjectMapper"
obmc_mapper_busname="xyz.openbmc_project.ObjectMapper"
obmc_mapper_query_iface="xyz.openbmc_project.ObjectMapper"

obmc_inventory_manager_iface="xyz.openbmc_project.Inventory.Manager"
