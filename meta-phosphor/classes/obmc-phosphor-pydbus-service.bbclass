# Common code for applications providing a D-Bus service using python-dbus bindings.

# Class users should define DBUS_SERVICES prior to including.

inherit obmc-phosphor-dbus-service
inherit obmc-phosphor-py-daemon
