namespace_dir="${datadir}/phosphor-mapper/namespace"
service_dir="${datadir}/phosphor-mapper/service"
interface_dir="${datadir}/phosphor-mapper/interface"
serviceblacklist_dir="${datadir}/phosphor-mapper/serviceblacklist"
