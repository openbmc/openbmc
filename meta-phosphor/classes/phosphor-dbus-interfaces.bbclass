yaml_dir="${datadir}/phosphor-dbus-interfaces/yaml"
error_yaml_dir="${datadir}/error/yaml"
