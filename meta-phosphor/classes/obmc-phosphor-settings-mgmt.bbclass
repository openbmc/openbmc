# Common code for recipes that implement Phosphor OpenBMC settings management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-settings-mgmt"
PROVIDES += "virtual/obmc-phosphor-settings-mgmt"
