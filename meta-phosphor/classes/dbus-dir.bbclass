dbus_system_confdir="${datadir}/dbus-1/system.d/"
dbus_system_servicesdir="${datadir}/dbus-1/system-services/"
