presence_datadir="${datadir}/phosphor-fan-presence"
control_datadir="${datadir}/phosphor-fan-control"
