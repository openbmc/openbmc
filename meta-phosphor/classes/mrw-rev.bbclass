MRW_API_SRC_URI ?= "git://github.com/open-power/serverwiz.git;subpath=scripts"
MRW_API_SRCREV ?= "60c8e10cbb11768cd1ba394b35cb1d6627efec42"

MRW_TOOLS_SRC_URI ?= "git://github.com/openbmc/phosphor-mrw-tools"
MRW_TOOLS_SRCREV ?= "00cef2c2afc92ded1acfc54c76ab0d46ae580023"
