# Common code for recipes that implement Phosphor OpenBMC user management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-user-mgmt"
PROVIDES += "virtual/obmc-phosphor-user-mgmt"
