# Common code for recipes that implement Phosphor OpenBMC policy management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-policy-mgmt"
PROVIDES += "virtual/obmc-phosphor-policy-mgmt"
