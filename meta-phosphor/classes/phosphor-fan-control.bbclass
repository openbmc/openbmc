control_datadir="${datadir}/phosphor-fan-control"
