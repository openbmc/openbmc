inherit pythonnative

DEPENDS += " \
        python-pyyaml-native \
        python-mako-native \
        python-inflection-native \
        sdbusplus-native \
        "
