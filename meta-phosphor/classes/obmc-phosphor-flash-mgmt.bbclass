# Common code for recipes that implement Phosphor OpenBMC flash management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-flash-mgmt"
