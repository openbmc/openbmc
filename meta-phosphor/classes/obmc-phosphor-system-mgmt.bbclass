# Common code for recipes that implement Phosphor OpenBMC system management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-system-mgmt"
PROVIDES += "virtual/obmc-phosphor-system-mgmt"
