# Common code for recipes that implement Phosphor OpenBMC sensor management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-sensor-mgmt"
