# Common code for recipes that implement Phosphor OpenBMC chassis management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-chassis-mgmt"
