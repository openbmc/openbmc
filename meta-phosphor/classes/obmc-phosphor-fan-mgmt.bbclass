# Common code for recipes that implement Phosphor OpenBMC fan management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-fan-mgmt"
PROVIDES += "virtual/obmc-phosphor-fan-mgmt"
