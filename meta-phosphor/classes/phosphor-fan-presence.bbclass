presence_datadir="${datadir}/phosphor-fan-presence"
