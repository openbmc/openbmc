# Common code for recipes that implement Phosphor OpenBMC IPMI HW to DBUS translation.

RPROVIDES_${PN} += "virtual/obmc-phosphor-host-ipmi-hw"
PROVIDES += "virtual/obmc-phosphor-host-ipmi-hw"
