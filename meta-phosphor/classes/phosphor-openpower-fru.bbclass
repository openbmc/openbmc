vpdlayout_datadir="${datadir}/phosphor-openpower-fru/vpdlayout"
