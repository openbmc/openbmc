settings_datadir="${datadir}/phosphor-settings/default"
