base_datadir="${datadir}/phosphor-inventory-manager"
rules_datadir="${base_datadir}/events.d"
