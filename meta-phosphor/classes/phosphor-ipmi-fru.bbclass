hostfw_datadir="${datadir}/phosphor-ipmi-fru/hostfw"
