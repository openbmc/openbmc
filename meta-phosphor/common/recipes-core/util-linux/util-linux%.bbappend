PACKAGES =+ "util-linux-fsck.minix"
FILES_util-linux-fsck.minix = "${base_sbindir}/fsck.minix*"
ALTERNATIVE_util-linux-fsck.minix = "fsck.minix"
ALTERNATIVE_util-linux-fsck_remove = "fsck.minix"
