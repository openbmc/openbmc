RRECOMMENDS_${PN}_append = " googletest sdbusplus phosphor-logging"
