RDEPENDS_${PN}_append = " \
        nativesdk-autoconf-archive-dev \
        nativesdk-phosphor-dbus-interfaces \
        nativesdk-openpower-dbus-interfaces \
        nativesdk-sdbus++ \
        "
