# TODO: openbmc/openbmc#298 - Move to devtools.
RDEPENDS_${PN} += "strace"
