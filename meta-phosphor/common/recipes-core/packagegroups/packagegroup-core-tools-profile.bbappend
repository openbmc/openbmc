RDEPENDS_${PN}_remove = " \
              lttng-tools \
              lttng-ust \
              lttng-modules \
              powertop \
              latencytop \
              "

RRECOMMENDS_${PN}_remove = " \
                 perf \
                 trace-cmd \
                 "
