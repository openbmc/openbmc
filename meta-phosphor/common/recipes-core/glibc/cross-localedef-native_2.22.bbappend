SRC_URI += "file://0001-add-support-for-Power8-LE-mode.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
