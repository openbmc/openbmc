EXTRA_OECONF_append += " --disable-largefile --disable-locale --disable-iconv --disable-acl-support --disable-xattr-support --without-included-popt --without-included-zlib"
