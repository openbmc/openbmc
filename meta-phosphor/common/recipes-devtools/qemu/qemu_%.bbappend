# TODO: openbmc/openbmc#1407 - Remove with RHEL6 support deprecation.
LDFLAGS_remove_class-native = " -fuse-ld=bfd"
