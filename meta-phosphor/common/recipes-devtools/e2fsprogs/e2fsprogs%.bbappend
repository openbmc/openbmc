EXTRA_OECONF += " --enable-symlink-install"
