FILESEXTRAPATHS_append := "${THISDIR}/gcc_6.2:"
SRC_URI_append = "file://0001-Support-exception-propagation-without-lock-free-atom.patch"
