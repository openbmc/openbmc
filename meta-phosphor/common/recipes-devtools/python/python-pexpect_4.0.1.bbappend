RDEPENDS_${PN}_append = "python-ptyprocess"
