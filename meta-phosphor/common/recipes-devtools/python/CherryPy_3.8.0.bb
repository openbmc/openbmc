require CherryPy.inc
SRC_URI = "https://pypi.python.org/packages/source/C/${BPN}/${BP}.tar.gz;name=tarball"
SRC_URI[tarball.sha256sum] = "ffcdb43667d4098247efaf8c82dd36d3dd4f8e5dc768ef5e90b480899e523bea"
SRC_URI[tarball.md5sum] = "542b96b2cd825e8120e8cd822bc18f4b"
