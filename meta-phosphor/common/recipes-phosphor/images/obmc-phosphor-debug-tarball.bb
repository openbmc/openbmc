DESCRIPTION = "Debug tools tarball for use with OpenBMC Phosphor"

inherit obmc-phosphor-debug-tarball
