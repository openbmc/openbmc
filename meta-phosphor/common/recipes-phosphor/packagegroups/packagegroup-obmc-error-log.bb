SUMMARY = "Phosphor OpenBMC - eror log file generation"
PR = "r1"

inherit packagegroup
inherit obmc-phosphor-license

deltask populate_sysroot
