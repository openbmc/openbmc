DEPENDS += "virtual/phosphor-ipmi-host-error"
