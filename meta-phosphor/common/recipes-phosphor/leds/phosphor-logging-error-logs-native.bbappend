DEPENDS += "phosphor-led-manager-error-native"
