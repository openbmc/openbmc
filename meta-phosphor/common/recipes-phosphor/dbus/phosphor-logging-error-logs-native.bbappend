DEPENDS += "phosphor-dbus-interfaces-native"
