FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
