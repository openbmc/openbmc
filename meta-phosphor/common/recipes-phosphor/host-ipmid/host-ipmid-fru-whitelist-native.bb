SUMMARY = "Whitelisted IPMI FRU Parser commands"
DESCRIPTION = "Whitelisted IPMI FRU Parser commands for OpenBMC"

inherit obmc-phosphor-license
inherit native
inherit obmc-phosphor-host-ipmid-whitelist
