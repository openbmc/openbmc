BBCLASSEXTEND += "nativesdk"
