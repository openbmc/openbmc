FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-syscfg-Add-ppc64le-cross-build-support.patch"
