FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

include u-boot-aspeed.inc

python do_configure () {
    pass
}
