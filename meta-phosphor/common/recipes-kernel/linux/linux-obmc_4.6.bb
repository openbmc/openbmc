KBRANCH ?= "dev-4.6"
LINUX_VERSION ?= "4.6"
SRCREV="openbmc-20160713-1"

require linux-obmc.inc
