KBRANCH ?= "dev-4.13"
LINUX_VERSION ?= "4.13.16"

SRCREV="a1340b5c31182ee3e191ac745f8e591badaeb586"

require linux-obmc.inc
