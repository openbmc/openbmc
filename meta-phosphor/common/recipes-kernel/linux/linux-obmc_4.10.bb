KBRANCH ?= "dev-4.10"
LINUX_VERSION ?= "4.10.17"

SRCREV="54a3c0a2f9a41223628986df5ffeb4e869d6ba04"

require linux-obmc.inc
