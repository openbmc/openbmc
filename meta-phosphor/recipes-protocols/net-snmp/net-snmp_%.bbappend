EXTRA_OECONF += "--disable-mib-loading \
                 --disable-debugging \
                 --disable-md5 \
                 --disable-des \
                 --disable-snmpv1 \
                 "
