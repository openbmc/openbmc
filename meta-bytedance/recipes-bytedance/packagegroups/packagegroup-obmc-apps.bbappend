RDEPENDS:${PN}-extras:append = " phosphor-misc-usb-ctrl usb-network"
