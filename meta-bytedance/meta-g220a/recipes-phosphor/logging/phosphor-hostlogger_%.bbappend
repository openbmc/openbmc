DEFAULT_INSTANCE = "ttyS2"
