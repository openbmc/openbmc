RDEPENDS:${PN}:append = "\
    lsof \
    curl \
"
