EXTRA_OEMESON:append = " \
    -Dhttp-body-limit=65 \
"

PACKAGECONFIG:append = "dbus-rest"
