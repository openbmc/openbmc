FILESEXTRAPATHS:prepend:ncplite := "${THISDIR}/${BPN}:"
