PACKAGECONFIG:append = " \
    redfish-dbus-log \
"

PACKAGECONFIG:remove= " \
    kvm \
"
