OBMC_IMAGE_EXTRA_INSTALL:append = " \
    ipmitool \
    usbutils \
    ethtool \
    "
