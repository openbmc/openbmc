PACKAGECONFIG:append = " smbios-ipmi-blob"
