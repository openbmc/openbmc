PACKAGECONFIG:append:ncplite = " log-threshold log-watchdog log-alarm send-to-logger"
