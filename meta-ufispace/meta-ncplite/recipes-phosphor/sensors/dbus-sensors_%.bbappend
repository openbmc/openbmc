PACKAGECONFIG:remove = " intrusionsensor ipmbsensor external nvmesensor"
