FILESEXTRAPATHS:prepend:ncplite := "${THISDIR}/${BPN}:"
SRC_URI += "file://ncplite.cfg"
