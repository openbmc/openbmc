INSANE_SKIP:${PN}-context:aspeed-g5 = "textrel"