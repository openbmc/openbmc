FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-otptool-Define-value_start-in-rev_id-path.patch"

