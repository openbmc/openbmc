include socsec.inc

PV = "1.0.3+git${SRCPV}"
SRCREV = "984eba09f4133bdb1e47eb5623be4881a9c65d87"
