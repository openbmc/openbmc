include socsec.inc

PV = "1.0.0+git${SRCPV}"
SRCREV = "2787a252988f4811097995ef9e807b1b433bde9f"
