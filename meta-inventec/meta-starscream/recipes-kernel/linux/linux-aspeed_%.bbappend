FILESEXTRAPATHS:append:starscream := "${THISDIR}/${BPN}:"

SRC_URI:append = " file://starscream.cfg \
                "
