FILESEXTRAPATHS:prepend:starscream := "${THISDIR}/${BPN}:"
