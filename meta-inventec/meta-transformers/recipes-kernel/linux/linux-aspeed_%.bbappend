FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI:append = " file://transformers.cfg \
                 "
