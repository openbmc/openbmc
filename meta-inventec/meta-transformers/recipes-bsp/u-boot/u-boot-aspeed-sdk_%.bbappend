FILESEXTRAPATHS:append := "${THISDIR}/${BPN}:"


SRC_URI:append = " file://transformers-ast2600.cfg \
                 "
