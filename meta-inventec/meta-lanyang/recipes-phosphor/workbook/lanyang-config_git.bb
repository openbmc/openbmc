SUMMARY = "Lanyang board wiring"
DESCRIPTION = "Board wiring information for the Lanyang OpenPOWER system."
PR = "r1"
PV = "1.0+git${SRCPV}"

inherit config-in-skeleton
