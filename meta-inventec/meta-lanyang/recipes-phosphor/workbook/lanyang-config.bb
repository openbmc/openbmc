SUMMARY = "Lanyang board wiring"
DESCRIPTION = "Board wiring information for the Lanyang OpenPOWER system."
PR = "r1"

inherit config-in-skeleton
