RDEPENDS_${PN} += 'avsbus-control'
RDEPENDS_${PN}_remove += "p9-vcs-workaround"
