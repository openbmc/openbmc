SUMMARY = "Barreleye board wiring"
DESCRIPTION = "Board wiring information for the Barreleye system."
PR = "r1"

inherit config-in-skeleton
