FILESEXTRAPATHS_prepend_barreleye := "${THISDIR}/${PN}:"
SRC_URI += "file://barreleye.cfg"
