# Common code for recipes that implement Phosphor OpenBMC event management.

RPROVIDES_${PN} += "virtual/obmc-phosphor-event-mgmt"
