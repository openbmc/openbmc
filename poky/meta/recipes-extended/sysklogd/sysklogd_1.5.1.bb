require sysklogd.inc

SRCREV = "930a2b1c0d15b14309a49f14e3f30e905456af4d"
