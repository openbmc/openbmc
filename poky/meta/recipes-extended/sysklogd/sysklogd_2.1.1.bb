require sysklogd.inc

SRCREV = "24dafe9a27ac959ebeb89acd3ebd3d62cca4b755"
