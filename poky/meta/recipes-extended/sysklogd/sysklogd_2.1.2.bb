require sysklogd.inc

SRCREV = "6d6010add698370fc7d9828f0aaa18613dd2397f"
