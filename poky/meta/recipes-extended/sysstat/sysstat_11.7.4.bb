require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a23a74b3f4caf9616230789d94217acb"

SRC_URI += "file://0001-Include-needed-headers-explicitly.patch"

SRC_URI[md5sum] = "421f958db80e67a27eda1ff6b8ebcdeb"
SRC_URI[sha256sum] = "a96265a22784c29888669f961a0896841d177853f8f057efe063e891962b9090"
