require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a23a74b3f4caf9616230789d94217acb"

SRC_URI += "file://0001-configure.in-remove-check-for-chkconfig.patch"

SRC_URI[md5sum] = "1073fdf7bba58483a467a8a0681beeda"
SRC_URI[sha256sum] = "78388b64acec81378b962e66b40e57acd4b18ff17a849bc9308f95d290248c9c"
