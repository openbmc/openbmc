require xcb-util.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://src/xcb_aux.c;endline=30;md5=ae305b9c2a38f9ba27060191046a6460 \
                    file://src/xcb_event.h;endline=27;md5=627be355aee59e1b8ade80d5bd90fad9"

SRC_URI[md5sum] = "2e97feed81919465a04ccc71e4073313"
SRC_URI[sha256sum] = "46e49469cb3b594af1d33176cd7565def2be3fa8be4371d62271fabb5eae50e9"
