require ${BPN}.inc

DRIDRIVERS_append_x86_class-target = ",r100,r200,nouveau,i965"
DRIDRIVERS_append_x86-64_class-target = ",r100,r200,nouveau,i965"

