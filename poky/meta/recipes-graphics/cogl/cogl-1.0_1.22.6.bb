require cogl-1.0.inc

SRC_URI[archive.md5sum] = "7bcc01edb5462d4d08d01bf893feddb0"
SRC_URI[archive.sha256sum] = "6d134bd3e48c067507167c001200b275997fb9c68b08b48ff038211c8c251b75"

LIC_FILES_CHKSUM = "file://COPYING;md5=1b1a508d91d25ca607c83f92f3e31c84"
