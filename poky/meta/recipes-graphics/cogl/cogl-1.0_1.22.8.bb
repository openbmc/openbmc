require cogl-1.0.inc

SRC_URI += "file://0001-configure.ac-don-t-require-eglmesaext.h.patch"
SRC_URI[archive.sha256sum] = "a805b2b019184710ff53d0496f9f0ce6dcca420c141a0f4f6fcc02131581d759"

LIC_FILES_CHKSUM = "file://COPYING;md5=1b1a508d91d25ca607c83f92f3e31c84"
