require cogl-1.0.inc

SRC_URI[archive.md5sum] = "31755015a865c4af51ac84f6e53af8ab"
SRC_URI[archive.sha256sum] = "5217bf94cbca3df63268a3b79d017725382b9e592b891d1e7dc6212590ce0de0"

LIC_FILES_CHKSUM = "file://COPYING;md5=1b1a508d91d25ca607c83f92f3e31c84"
