require xorg-proto-common.inc

SUMMARY = "Xv: X Video extension headers"

DESCRIPTION = "This package provides the wire protocol for the X Video \
extension.  This extension alows for accerlated drawing of videos."

LICENSE = "MIT & MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=ce3472a119a864085fa4155cb0979a7b"

PE = "1"

SRC_URI[md5sum] = "fe86de8ea3eb53b5a8f52956c5cd3174"
SRC_URI[sha256sum] = "c7803889fd08e6fcaf7b68cc394fb038b2325d1f315e571a6954577e07cca702"
