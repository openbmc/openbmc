#
# Copyright OpenEmbedded Contributors
#
# SPDX-License-Identifier: MIT
#

inherit python_pep517 python3native python3-dir setuptools3-base

DEPENDS += "python3-hatchling-native"
