#
# Copyright OpenEmbedded Contributors
#
# SPDX-License-Identifier: MIT
#

PYTHON_BASEVERSION = "3.12"
PYTHON_ABI = ""
PYTHON_DIR = "python${PYTHON_BASEVERSION}"
PYTHON_PN = "python3"
PYTHON_SITEPACKAGES_DIR = "${libdir}/${PYTHON_DIR}/site-packages"
