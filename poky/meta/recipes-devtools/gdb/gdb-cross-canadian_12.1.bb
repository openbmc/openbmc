require gdb-common.inc
require gdb-cross-canadian.inc
require gdb.inc
