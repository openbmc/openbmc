inherit setuptools3
require python-numpy.inc

