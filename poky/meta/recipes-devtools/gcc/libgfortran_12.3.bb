require recipes-devtools/gcc/gcc-${PV}.inc
require libgfortran.inc

