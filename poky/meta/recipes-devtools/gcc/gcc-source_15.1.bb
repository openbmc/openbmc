require recipes-devtools/gcc/gcc-${PV}.inc
require recipes-devtools/gcc/gcc-source.inc

BPN = "gcc-source"
EXCLUDE_FROM_WORLD = "1"
