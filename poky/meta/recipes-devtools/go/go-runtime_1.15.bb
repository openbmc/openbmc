export CGO_ENABLED_riscv64 = ""
require go-${PV}.inc
require go-runtime.inc

