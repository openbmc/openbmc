require ${PN}.inc
require go-${PV}.inc

GOMAKEARGS = "--host-only --no-banner"
