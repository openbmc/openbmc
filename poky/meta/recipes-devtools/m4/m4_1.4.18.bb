require m4-${PV}.inc

BBCLASSEXTEND = "nativesdk"
