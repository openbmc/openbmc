inherit setuptools3
require python-gitdb.inc

SRC_URI[md5sum] = "3f52187435ab0b6e64a15782ffaf29ab"
