require python-pycryptodome.inc
inherit setuptools3

SRC_URI[sha256sum] = "910e202a557e1131b1c1b3f17a63914d57aac55cf9fb9b51644962841c3995c4"

