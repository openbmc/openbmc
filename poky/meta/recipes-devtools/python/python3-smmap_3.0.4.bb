inherit setuptools3
require python-smmap.inc

