require python-pycryptodome.inc
inherit setuptools3

SRC_URI[sha256sum] = "12c7343aec5a3b3df5c47265281b12b611f26ec9367b6129199d67da54b768c1"

