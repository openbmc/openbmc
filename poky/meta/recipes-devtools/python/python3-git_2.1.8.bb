require python-git.inc
inherit setuptools3
