require python-pycryptodome.inc
inherit setuptools3

SRC_URI[sha256sum] = "3e2e3a06580c5f190df843cdb90ea28d61099cf4924334d5297a995de68e4673"

