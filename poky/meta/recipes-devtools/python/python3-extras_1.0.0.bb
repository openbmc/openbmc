inherit setuptools3
require python-extras.inc
