inherit setuptools3
require python-pbr.inc

SRC_URI[md5sum] = "ab6e26026ab306989a636ec2d50a435a"
SRC_URI[sha256sum] = "0ca44dc9fd3b04a22297c2a91082d8df2894862e8f4c86a49dac69eae9e85ca0"
