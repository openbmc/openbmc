inherit pypi setuptools3
require python-pyasn1.inc

