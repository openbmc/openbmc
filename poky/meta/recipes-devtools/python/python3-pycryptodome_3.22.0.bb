require python-pycryptodome.inc
inherit python_setuptools_build_meta

SRC_URI[sha256sum] = "fd7ab568b3ad7b77c908d7c3f7e167ec5a8f035c64ff74f10d47a4edd043d723"

