inherit setuptools3
require python-six.inc

SRC_URI[md5sum] = "9f90a0eaa0ea7747fda01ca79d21ebcb"
SRC_URI[sha256sum] = "30639c035cdb23534cd4aa2dd52c3bf48f06e5f4a941509c8bafd8ce11080259"
