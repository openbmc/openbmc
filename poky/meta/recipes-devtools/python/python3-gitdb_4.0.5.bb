inherit setuptools3
require python-gitdb.inc

SRC_URI[md5sum] = "0e2d3f34efece5deda7c55fede6507cc"
