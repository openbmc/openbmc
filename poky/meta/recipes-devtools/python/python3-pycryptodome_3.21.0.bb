require python-pycryptodome.inc
inherit python_setuptools_build_meta

SRC_URI[sha256sum] = "f7787e0d469bdae763b876174cf2e6c0f7be79808af26b1da96f1a64bcf47297"

