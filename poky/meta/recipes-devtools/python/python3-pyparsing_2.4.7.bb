inherit setuptools3
require python-pyparsing.inc

