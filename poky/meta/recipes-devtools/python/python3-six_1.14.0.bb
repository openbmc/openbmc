inherit setuptools3
require python-six.inc

SRC_URI[md5sum] = "21674588a57e649d1a6d977ec3122140"
SRC_URI[sha256sum] = "236bdbdce46e6e6a3d61a337c0f8b763ca1e8717c03b369e87a7ec7ce1319c0a"
