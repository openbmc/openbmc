require python-pycryptodome.inc
inherit setuptools3

SRC_URI[sha256sum] = "bc35d463222cdb4dbebd35e0784155c81e161b9284e567e7e933d722e533331e"

