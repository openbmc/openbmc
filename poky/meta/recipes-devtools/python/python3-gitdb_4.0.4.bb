inherit setuptools3
require python-gitdb.inc

