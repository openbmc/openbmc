inherit setuptools3
require python-pbr.inc
SRC_URI[md5sum] = "bea55678345bd77b4ff5b2ebb729fd6d"
SRC_URI[sha256sum] = "d717573351cfe09f49df61906cd272abaa759b3e91744396b804965ff7bff38b"

