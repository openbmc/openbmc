inherit setuptools3
require python-testtools.inc
