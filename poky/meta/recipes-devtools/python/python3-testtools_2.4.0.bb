inherit setuptools3
require python-testtools.inc

SRC_URI += "file://no_traceback2.patch"
