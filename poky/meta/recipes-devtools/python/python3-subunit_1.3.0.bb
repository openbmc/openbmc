inherit setuptools3
require python-subunit.inc
