inherit setuptools3
require python-pbr.inc
