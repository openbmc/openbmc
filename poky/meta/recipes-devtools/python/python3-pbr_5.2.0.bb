inherit setuptools3
require python-pbr.inc
SRC_URI[md5sum] = "2bca008fd08d035a2f78c606d876a6db"
SRC_URI[sha256sum] = "d950c64aeea5456bbd147468382a5bb77fe692c13c9f00f0219814ce5b642755"

