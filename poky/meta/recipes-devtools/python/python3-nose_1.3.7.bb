inherit setuptools3
require python-nose.inc
