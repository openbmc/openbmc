# check src/llvm-project/llvm/CMakeLists.txt for llvm version in use
#
LLVM_RELEASE = "12.0.1"
require rust-source-${PV}.inc
require rust-llvm.inc
