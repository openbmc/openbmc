# check src/llvm-project/llvm/CMakeLists.txt for llvm version in use
#
LLVM_RELEASE = "13.0.0"
require rust-source.inc
require rust-llvm.inc

