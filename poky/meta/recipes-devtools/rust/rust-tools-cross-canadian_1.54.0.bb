require rust-tools-cross-canadian.inc
require rust-source-${PV}.inc
require rust-snapshot-${PV}.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/rust:"

