inherit distutils

DEPENDS += "python-setuptools-native"
