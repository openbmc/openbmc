DEPENDS:prepend = "pkgconfig-native "

