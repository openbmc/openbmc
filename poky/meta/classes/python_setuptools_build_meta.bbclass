inherit setuptools3-base python_pep517

DEPENDS += "python3-setuptools-native python3-wheel-native"

PEP517_BUILD_API = "setuptools.build_meta"
