require u-boot-common.inc
require u-boot-tools.inc

SRC_URI += "file://0001-Revert-config-tools-only-add-VIDEO-to-build-bmp_logo.patch"
