require u-boot-common.inc
require u-boot-tools.inc

