require u-boot-common.inc
require u-boot.inc

DEPENDS += "bc-native dtc-native gnutls-native python3-pyelftools-native"
