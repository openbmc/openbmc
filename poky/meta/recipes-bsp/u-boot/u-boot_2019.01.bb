require u-boot-common.inc
require u-boot.inc

DEPENDS += "bc-native dtc-native"
