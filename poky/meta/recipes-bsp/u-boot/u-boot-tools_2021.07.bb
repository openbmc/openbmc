require u-boot-common.inc
require u-boot-tools.inc

SRC_URI:append = " file://0001-tools-image-host-fix-wrong-return-value.patch"
