require u-boot-common.inc
require u-boot-tools.inc

SRC_URI += " \
    file://0001-mkimage-Use-PATH_MAX-for-path-length.patch \
"
