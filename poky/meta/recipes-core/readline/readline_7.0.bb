require readline.inc

SRC_URI += "file://configure-fix.patch \
            file://norpath.patch"

SRC_URI[archive.md5sum] = "205b03a87fc83dab653b628c59b9fc91"
SRC_URI[archive.sha256sum] = "750d437185286f40a369e1e4f4764eda932b9459b5ec9a731628393dd3d32334"
