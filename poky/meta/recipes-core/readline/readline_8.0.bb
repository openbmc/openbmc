require readline.inc

SRC_URI += "file://configure-fix.patch \
            file://norpath.patch"

SRC_URI[archive.md5sum] = "7e6c1f16aee3244a69aba6e438295ca3"
SRC_URI[archive.sha256sum] = "e339f51971478d369f8a053a330a190781acb9864cf4c541060f12078948e461"
