require glibc-scripts.inc
