require glibc-locale.inc
