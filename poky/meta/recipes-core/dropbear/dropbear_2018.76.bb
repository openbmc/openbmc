require dropbear.inc

SRC_URI[md5sum] = "c3912f7fcdcc57c99937e4a79480d2c2"
SRC_URI[sha256sum] = "f2fb9167eca8cf93456a5fc1d4faf709902a3ab70dd44e352f3acbc3ffdaea65"

