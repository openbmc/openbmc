require dropbear.inc

SRC_URI[md5sum] = "5d4f0256c5d13820b0a3eaadb1a0bc1a"
SRC_URI[sha256sum] = "d91f78ebe633be1d071fd1b7e5535b9693794048b019e9f4bea257e1992b458d"
