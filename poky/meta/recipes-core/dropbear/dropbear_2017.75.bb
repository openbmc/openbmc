require dropbear.inc

SRC_URI[md5sum] = "e57e9b9d25705dcb073ba15c416424fd"
SRC_URI[sha256sum] = "6cbc1dcb1c9709d226dff669e5604172a18cf5dbf9a201474d5618ae4465098c"

