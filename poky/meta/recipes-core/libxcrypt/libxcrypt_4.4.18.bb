require libxcrypt.inc

