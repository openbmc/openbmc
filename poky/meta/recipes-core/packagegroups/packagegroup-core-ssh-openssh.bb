SUMMARY = "OpenSSH SSH client/server"
PR = "r1"

inherit packagegroup

RDEPENDS:${PN} = "openssh"
