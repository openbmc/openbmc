require core-image-ptest-all.bb

DESCRIPTION = "Recipe to trigger execution of all fast ptest images."

PTESTS = "${PTESTS_FAST}"

