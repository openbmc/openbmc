require sqlite3.inc

LICENSE = "PD"
LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=786d3dc581eff03f4fd9e4a77ed00c66"

SRC_URI = "http://www.sqlite.org/2024/sqlite-autoconf-${SQLITE_PV}.tar.gz"
SRC_URI[sha256sum] = "f1b2ee412c28d7472bc95ba996368d6f0cdcf00362affdadb27ed286c179540b"

