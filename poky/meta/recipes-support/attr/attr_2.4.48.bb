require attr.inc

SRC_URI[md5sum] = "bc1e5cb5c96d99b24886f1f527d3bb3d"
SRC_URI[sha256sum] = "5ead72b358ec709ed00bbf7a9eaef1654baad937c001c044fe8b74c57f5324e7"

BBCLASSEXTEND = "native nativesdk"
