require attr.inc

SRC_URI[sha256sum] = "bae1c6949b258a0d68001367ce0c741cebdacdd3b62965d17e5eb23cd78adaf8"

BBCLASSEXTEND = "native nativesdk"
