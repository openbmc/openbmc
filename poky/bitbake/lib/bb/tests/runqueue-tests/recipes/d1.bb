DEPENDS = "a1"

do_package_setscene[depends] = "a1:do_populate_sysroot_setscene"
