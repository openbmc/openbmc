do_rootfs[recrdeptask] += "do_package_write_deb do_package_qa"
do_rootfs[recrdeptask] += "do_package_write_ipk do_package_qa"
do_rootfs[recrdeptask] += "do_package_write_rpm do_package_qa
do_rootfs[recrdeptask] += "do_packagedata"
do_rootfs[recrdeptask] += "do_populate_lic"
