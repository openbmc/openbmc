# This bbappend is used to alter the recipe using the test_recipe.inc file created by tests.
include test_recipe.inc
