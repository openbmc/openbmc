IMAGE_INSTALL += "container-image-testpkg"

LICENSE = "MIT"

IMAGE_FSTYPES = "container"
IMAGE_LINGUAS = ""
IMAGE_FEATURES = ""

inherit core-image
