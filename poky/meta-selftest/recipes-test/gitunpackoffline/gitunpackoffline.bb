require gitunpackoffline-fail.bb

TAGVALUE = "2.11"

PV = "0.0+git${SRCPV}"
