FILESEXTRAPATHS:prepend:poky := "${THISDIR}/files:"

