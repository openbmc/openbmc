# yocto-bsp-filename {{=example_bbappend_name}}_{{=example_bbappend_version}}.bbappend
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

#
# This .bbappend doesn't yet do anything - replace this text with
# modifications to the example_0.1.bb recipe, or whatever recipe it is
# that you want to modify with this .bbappend (make sure you change
# the recipe name (PN) and version (PV) to match).
#
