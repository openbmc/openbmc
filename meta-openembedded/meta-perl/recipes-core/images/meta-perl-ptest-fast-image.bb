require meta-perl-ptest-all-image.bb

DESCRIPTION = "Recipe to trigger execution of all fast meta-perl ptest images."

PTESTS_META_PERL = "${PTESTS_FAST_META_PERL}"

