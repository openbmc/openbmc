require libmediaart.inc

SRC_URI = "${GNOME_MIRROR}/libmediaart/1.9/libmediaart-${PV}.tar.xz"
SRC_URI[md5sum] = "9b960a6a764fba38135fb57219f2e6b4"
SRC_URI[sha256sum] = "a57be017257e4815389afe4f58fdacb6a50e74fd185452b23a652ee56b04813d"

S = "${WORKDIR}/libmediaart-${PV}"
