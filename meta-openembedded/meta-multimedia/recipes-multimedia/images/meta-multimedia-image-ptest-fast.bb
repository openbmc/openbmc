require meta-multimedia-image-ptest-all.bb

DESCRIPTION = "Recipe to trigger execution of all fast meta-multimedia ptest images."

PTESTS_META_MULTIMEDIA = "${PTESTS_FAST_META_MULTIMEDIA}"
