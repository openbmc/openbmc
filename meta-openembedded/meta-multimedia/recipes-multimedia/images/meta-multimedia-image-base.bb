SUMMARY = "meta-multimedia build test image"

IMAGE_INSTALL = "packagegroup-core-boot"

LICENSE = "MIT"

inherit core-image
