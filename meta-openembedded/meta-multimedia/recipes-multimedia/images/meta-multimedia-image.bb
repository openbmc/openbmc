require  meta-multimedia-image-base.bb

IMAGE_INSTALL += "packagegroup-meta-multimedia"
