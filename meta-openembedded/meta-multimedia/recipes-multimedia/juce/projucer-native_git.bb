inherit native
include projucer.inc
BBCLASSEXTEND = "native"
