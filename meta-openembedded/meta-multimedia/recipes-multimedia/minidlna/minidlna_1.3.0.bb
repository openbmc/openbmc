require ${BPN}.inc

SRCREV = "109d63cb11ac207c18a784556834eb054b34b00b"
LIC_FILES_CHKSUM = "file://LICENCE.miniupnpd;md5=b0dabf9d8e0f871554e309d62ead8d2b"
