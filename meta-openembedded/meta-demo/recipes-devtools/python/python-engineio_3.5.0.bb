inherit setuptools
require python-engineio.inc
