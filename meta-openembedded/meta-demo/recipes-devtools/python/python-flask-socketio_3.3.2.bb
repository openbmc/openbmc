inherit setuptools
require python-flask-socketio.inc
