inherit setuptools3
require python-engineio.inc
