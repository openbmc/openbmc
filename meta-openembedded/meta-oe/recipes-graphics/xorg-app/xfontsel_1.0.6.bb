require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "xfontsel provides point and click selection of X11 font names"
HOMEPAGE = "http://cgit.freedesktop.org/xorg/app/xfontsel/"
SECTION = "x11/app"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=4669d2703c60d585cc29ba7e9a69bcb3"
DEPENDS += " libxaw"

LIC_FILES_CHKSUM = "file://COPYING;md5=4669d2703c60d585cc29ba7e9a69bcb3"

SRC_URI[md5sum] = "13150ff98846bf6d9a14bee00697fa47"
SRC_URI[sha256sum] = "25aa0b7c4262f5e99c07c2b96e00e4eb25b7e53f94fa803942af9d0e8da3001c"
