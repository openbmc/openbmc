require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "Display a message or query in a window"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=73c7f696a728de728d7446cbca814cc5"

DEPENDS += "libxaw"

SRC_URI[md5sum] = "e50ffae17eeb3943079620cb78f5ce0b"
SRC_URI[sha256sum] = "373dfb81e7a6f06d3d22485a12fcde6e255d58c6dee1bbaeb00c7d0caa9b2029"
