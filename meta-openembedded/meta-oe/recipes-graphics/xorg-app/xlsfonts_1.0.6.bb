require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "server font list displayer for X"
HOMEPAGE = "http://cgit.freedesktop.org/xorg/app/xlsfonts/"
SECTION = "x11/app"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=5ec74dd7ea4d10c4715a7c44f159a40b"

SRC_URI[md5sum] = "5774fd4f518b3f338f2b28f270e04bfc"
SRC_URI[sha256sum] = "89b80b3a030006ab6cef717be286c12f2477894b227158b1e6133274f6ebd368"
