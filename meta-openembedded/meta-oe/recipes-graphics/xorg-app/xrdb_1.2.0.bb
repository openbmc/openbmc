require recipes-graphics/xorg-app/xorg-app-common.inc
SUMMARY = "X server resource database utility"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=d1167c4f586bd41f0c62166db4384a69"

DEPENDS += "libxmu"

SRC_URI[md5sum] = "34ae801ef994d192c70fcce2bdb2a1b2"
SRC_URI[sha256sum] = "f23a65cfa1f7126040d68b6cf1e4567523edac10f8dc06f23d840d330c7c6946"
