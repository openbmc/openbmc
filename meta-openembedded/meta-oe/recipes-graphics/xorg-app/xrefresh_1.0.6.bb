require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "X.Org X11 X client utilities"
HOMEPAGE = "http://cgit.freedesktop.org/xorg/app/xrefresh/"
DESCRIPTION = "xrefresh - refresh all or part of an X screen"
SECTION = "x11/app"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=dad633bce9c3cd0e3abf72a16e0057cf"

BBCLASSEXTEND = "native"

SRC_URI[md5sum] = "c56fa4adbeed1ee5173f464a4c4a61a6"
SRC_URI[sha256sum] = "287dfb9bb7e8d780d07e672e3252150850869cb550958ed5f8401f0835cd6353"
