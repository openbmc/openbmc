require recipes-graphics/xorg-app/xorg-app-common.inc

SUMMARY = "server font list displayer for X"
HOMEPAGE = "http://cgit.freedesktop.org/xorg/app/xlsfonts/"
SECTION = "x11/app"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=5ec74dd7ea4d10c4715a7c44f159a40b"

SRC_URI_EXT = "xz"
SRC_URI[sha256sum] = "7b726945a967b44c35cddee5edd74802907a239ce2e2e515730b8a32c8e50465"
