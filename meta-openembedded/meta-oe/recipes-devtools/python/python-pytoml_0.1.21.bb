inherit pypi setuptools
require python-pytoml.inc
