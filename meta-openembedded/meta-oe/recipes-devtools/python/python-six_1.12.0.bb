inherit pypi setuptools
require recipes-devtools/python/python-six.inc
