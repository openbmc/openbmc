RDEPENDS:packagegroup-meta-oe-graphics +="\
    openbox-xdgmenu \
"
