RDEPENDS:packagegroup-meta-oe-support += " \
    thin-provisioning-tools \
"
