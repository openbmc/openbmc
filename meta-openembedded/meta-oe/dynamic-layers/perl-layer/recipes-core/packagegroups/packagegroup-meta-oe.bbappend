RDEPENDS:packagegroup-meta-oe-support += "debsums rasdaemon"
