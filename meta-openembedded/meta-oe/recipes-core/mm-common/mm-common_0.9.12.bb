inherit gnomebase

SRC_URI[archive.md5sum] = "be1c61587db989c7677375a729b94672"
SRC_URI[archive.sha256sum] = "ceffdcce1e5b52742884c233ec604bf6fded12eea9da077ce7a62c02c87e7c0b"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

BBCLASSEXTEND = "native"
