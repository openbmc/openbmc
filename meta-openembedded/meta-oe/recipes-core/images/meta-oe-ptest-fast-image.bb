require meta-oe-ptest-all-image.bb

DESCRIPTION = "Recipe to trigger execution of all fast meta-oe ptest images."

PTESTS_META_OE = "${PTESTS_FAST_META_OE}"

