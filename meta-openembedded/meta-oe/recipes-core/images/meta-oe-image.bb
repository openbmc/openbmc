require  meta-oe-image-base.bb

SUMMARY = "meta-oe build test image"

IMAGE_INSTALL += "packagegroup-meta-oe"
