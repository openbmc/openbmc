require augeas.inc

SRC_URI[md5sum] = "abf51f4c0cf3901d167f23687f60434a"
SRC_URI[sha256sum] = "393ce8f4055af89cd4c20bf903eacbbd909cf427891f41b56dc2ba66243ea0b0"
