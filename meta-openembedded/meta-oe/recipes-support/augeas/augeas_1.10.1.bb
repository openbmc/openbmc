require augeas.inc

SRC_URI[md5sum] = "6c0b2ea6eec45e8bc374b283aedf27ce"
SRC_URI[sha256sum] = "52db256afab261d31cc147eaa1a71795a5fec59e888dfd0b65a84c7aacd6364d"
