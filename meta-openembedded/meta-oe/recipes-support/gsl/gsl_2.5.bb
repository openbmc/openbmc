include gsl.inc

SRC_URI = "${GNU_MIRROR}/gsl/gsl-${PV}.tar.gz"

SRC_URI[md5sum] = "52fcbe147ba413d78841084cb43c95fb"
SRC_URI[sha256sum] = "0460ad7c2542caaddc6729762952d345374784100223995eb14d614861f2258d"
