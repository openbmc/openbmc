# helper class to prepare correct environment for native itstool

inherit python3native

DEPENDS_append = " itstool-native"
