require plocate.inc
# GPL-2.0-only
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRC_URI = "git://git.sesse.net/plocate;protocol=https;branch=master"

SRCREV = "7e5defd4e7e075cb9226e7d2d9a80f943c482d11"
S = "${WORKDIR}/git"
