require geos.inc

SRC_URI += "file://geos-config-Add-includedir-variable.patch \
"

SRC_URI[md5sum] = "77f2c2cca1e9f49bc1bece9037ac7a7a"
SRC_URI[sha256sum] = "cfbf68079117c1c2b76411636444ff41d73c31093c4cab9dcc9a8c1bbe7e3897"
