include cups-filters.inc

SRC_URI[md5sum] = "970095596bf2b8cfe91ac91c0b51297a"
SRC_URI[sha256sum] = "0069aef1358522f1901a64749ec753d28a2d6a832758bce58ffcd722b28c0e66"
