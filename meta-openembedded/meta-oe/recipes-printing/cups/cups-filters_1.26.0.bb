include cups-filters.inc

SRC_URI[md5sum] = "afb278c77bb195c2a32fc64e5c8378fb"
SRC_URI[sha256sum] = "ff8679fcd0c31c25d229262c7ad100ba161ef6b2aa455a2df673dd74ef93f488"
