include cups-filters.inc

SRC_URI[md5sum] = "90ebcae31f2eabd802236408646b1dd9"
SRC_URI[sha256sum] = "174a2a5c919bf88c63ced692a2170add6c2cd70ff06c49bcea32e9cf56960492"
