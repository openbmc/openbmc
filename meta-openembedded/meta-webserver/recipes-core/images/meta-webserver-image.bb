require  meta-webserver-image-base.bb

IMAGE_INSTALL += "packagegroup-meta-webserver"
