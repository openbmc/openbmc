require recipes-core/images/core-image-base.bb

IMAGE_INSTALL += "packagegroup-meta-webserver"
