require nginx.inc

# 1.16.x branch is the current stable branch, the recommended default
# 1.17.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=52e384aaac868b755b93ad5535e2d075"

SRC_URI[md5sum] = "97207283f30cd90cdba638c3ea30323a"
SRC_URI[sha256sum] = "4fd376bad78797e7f18094a00f0f1088259326436b537eb5af69b01be2ca1345"
