require nginx.inc

# 1.12.x branch is the current stable branch, the recommended default
# 1.13.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=3691402cc54ce09f800ca348634a2dfe"

SRC_URI[md5sum] = "dcd482dd98d2022659212f183e8fe81b"
SRC_URI[sha256sum] = "5faea18857516fe68d30be39c3032bd22ed9cf85e1a6fdf32e3721d96ff7fa42"
