require nginx.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=a6547d7e5628787ee2a9c5a3480eb628"

SRC_URI[sha256sum] = "627fe086209bba80a2853a0add9d958d7ebbdffa1a8467a5784c9a6b4f03d738"

