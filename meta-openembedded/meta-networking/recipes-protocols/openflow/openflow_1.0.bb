include ${BPN}.inc

SRCREV = "5ccca75a69f99791659bcfbcf35353ab1921320a"
PV = "1.0"
