require xl2tpd.inc

# The SRCREV corresponds to v1.3.6.
# Adding tag=v1.3.6 to the SRC_URI will force access to the upstream repo.
#
SRCREV = "5619e1771048e74b729804e8602f409af0f3faea"

