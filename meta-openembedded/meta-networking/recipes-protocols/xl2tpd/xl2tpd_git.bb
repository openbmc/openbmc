require xl2tpd.inc

# This is v1.3.6 plus some commits.  There is no tag for this commit.
#
PV = "1.3.9+git${SRCPV}"

SRCREV = "f114c10ac532051badeca0132b144a2f1596f047"

