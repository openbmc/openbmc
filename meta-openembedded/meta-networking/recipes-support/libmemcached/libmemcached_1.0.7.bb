require libmemcached.inc

SRC_URI[md5sum] = "d59a462a92d296f76bff2d9bc72b2516"
SRC_URI[sha256sum] = "3efa86c9733eaad55d7119cb16769424e2aa6c22b3392e8f973946fce6678d81"
