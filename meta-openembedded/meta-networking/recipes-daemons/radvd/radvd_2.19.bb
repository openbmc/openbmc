
require radvd.inc

SRC_URI[md5sum] = "e9c425ac48ecb96ea5ea2912c78969f9"
SRC_URI[sha256sum] = "c36470706fec3a9e6bed394ffea08acaff5dac647848d26b96bb9b9c65d58da0"
