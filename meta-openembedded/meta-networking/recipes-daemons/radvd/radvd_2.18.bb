
require radvd.inc

SRC_URI[md5sum] = "26ead3a0d5cfbe4c81c3089eaf7b3250"
SRC_URI[sha256sum] = "4f573e36b96ba92d03b5abbbd5f059b9c8994967812c77852f44049ac5a448fd"
