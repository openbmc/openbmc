
require radvd.inc

SRC_URI[md5sum] = "64ee3fdb5544bcddef1c6cd80d77fa0a"
SRC_URI[sha256sum] = "53757e7f2164899e1145482f1ae91829600a6e2f6fec29cfb3b350a3bb45bd5d"
