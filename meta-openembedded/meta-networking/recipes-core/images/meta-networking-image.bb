require  meta-networking-image-base.bb

IMAGE_INSTALL += "packagegroup-meta-networking"
