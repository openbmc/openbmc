require python-pyconnman.inc

inherit setuptools3

RDEPENDS_${PN} += "python3-dbus python3-pprint"
