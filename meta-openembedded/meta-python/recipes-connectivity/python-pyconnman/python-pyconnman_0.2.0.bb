require python-pyconnman.inc

inherit setuptools

RDEPENDS_${PN} += "python-dbus python-pprint"
