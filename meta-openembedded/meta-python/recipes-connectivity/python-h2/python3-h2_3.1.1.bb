require python-h2.inc

inherit setuptools3
