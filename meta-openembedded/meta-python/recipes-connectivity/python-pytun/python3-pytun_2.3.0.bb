require python-pytun.inc
inherit setuptools3
