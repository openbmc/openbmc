require python-hyperframe.inc

inherit setuptools3
