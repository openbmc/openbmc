DESCRIPTION = "HTTP/2 framing layer for Python"
HOMEPAGE = "https://github.com/python-hyper/hyperframe"
LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE;md5=5bf1c68e73fbaec2b1687b7e71514393"

SRC_URI[sha256sum] = "ae510046231dc8e9ecb1a6586f63d2347bf4c8905914aa84ba585ae85f28a914"

inherit pypi setuptools3
