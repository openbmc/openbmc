DESCRIPTION = "HTTP/2 framing layer for Python"
HOMEPAGE = "https://github.com/python-hyper/hyperframe"
LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE;md5=5bf1c68e73fbaec2b1687b7e71514393"

SRC_URI[md5sum] = "30136a712e092b1a45ae3cad3ae93131"
SRC_URI[sha256sum] = "742d2a4bc3152a340a49d59f32e33ec420aa8e7054c1444ef5c7efff255842f1"

inherit pypi setuptools3
