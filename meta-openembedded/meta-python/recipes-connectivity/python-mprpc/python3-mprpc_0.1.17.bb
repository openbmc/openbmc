require python-mprpc.inc
inherit setuptools3
