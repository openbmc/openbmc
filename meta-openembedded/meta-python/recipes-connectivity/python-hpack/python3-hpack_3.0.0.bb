require python-hpack.inc

inherit setuptools3
