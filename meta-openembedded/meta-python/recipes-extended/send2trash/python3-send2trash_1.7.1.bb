SUMMARY = "Send file to trash natively under Mac OS X, Windows and Linux"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a02659c2d5f4cc626e4dcf6504b865eb"

inherit pypi setuptools3

SRC_URI[sha256sum] = "17730aa0a33ab82ed6ca76be3bb25f0433d0014f1ccf63c979bab13a5b9db2b2"

PYPI_PACKAGE = "Send2Trash"
