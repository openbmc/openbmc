SUMMARY = "Send file to trash natively under Mac OS X, Windows and Linux"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=05faa35ba1ca10b723f19d286c9d5237"

inherit pypi setuptools3

SRC_URI[sha256sum] = "60001cc07d707fe247c94f74ca6ac0d3255aabcb930529690897ca2a39db28b2"

PYPI_PACKAGE = "Send2Trash"
