inherit setuptools
require python-intervals.inc
