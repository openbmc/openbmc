inherit pypi setuptools3
require python-wcwidth.inc
