inherit setuptools3
require python-cachetools.inc
