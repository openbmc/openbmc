inherit setuptools
require python-wrapt.inc
