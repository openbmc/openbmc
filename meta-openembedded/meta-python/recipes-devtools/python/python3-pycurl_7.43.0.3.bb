inherit setuptools3
require python-pycurl.inc
