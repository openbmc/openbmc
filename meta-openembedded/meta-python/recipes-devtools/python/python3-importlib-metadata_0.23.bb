inherit pypi setuptools3
require python-importlib-metadata.inc

RDEPENDS_${PN} += "python3-misc"
