inherit setuptools
require python-rdflib.inc
