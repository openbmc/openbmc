DESCRIPTION = "A library for parsing ISO 8601 strings."

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ba35a7f4192a3ea09a01f4e8169a56bc"

SRC_URI[sha256sum] = "ff1d0fc2346688c62c0151547136ac30e322896ed8af316ef7602c47da9426cf"

inherit pypi setuptools3
