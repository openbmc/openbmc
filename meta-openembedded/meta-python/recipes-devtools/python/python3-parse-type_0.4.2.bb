inherit setuptools3
require python-parse-type.inc
