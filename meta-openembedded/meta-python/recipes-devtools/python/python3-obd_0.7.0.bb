inherit setuptools3
require python-obd.inc
