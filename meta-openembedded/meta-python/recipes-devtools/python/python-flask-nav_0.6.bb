inherit pypi setuptools
require python-flask-nav.inc
