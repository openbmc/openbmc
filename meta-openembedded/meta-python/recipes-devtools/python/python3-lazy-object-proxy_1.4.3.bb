inherit setuptools3
require python-lazy-object-proxy.inc
