inherit pypi setuptools
require python-flask-user.inc
