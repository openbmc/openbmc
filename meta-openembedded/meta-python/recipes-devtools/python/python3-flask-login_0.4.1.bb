inherit pypi setuptools3
require python-flask-login.inc
