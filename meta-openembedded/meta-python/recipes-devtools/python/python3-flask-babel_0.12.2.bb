inherit pypi setuptools3
require python-flask-babel.inc
