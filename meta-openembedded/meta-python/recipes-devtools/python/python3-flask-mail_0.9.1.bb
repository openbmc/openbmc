inherit pypi setuptools3
require python-flask-mail.inc
