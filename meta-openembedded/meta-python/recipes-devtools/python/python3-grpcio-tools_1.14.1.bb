inherit setuptools3
require python-grpcio-tools.inc
