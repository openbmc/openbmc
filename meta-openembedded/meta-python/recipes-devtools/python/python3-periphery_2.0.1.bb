inherit pypi setuptools3
require python-periphery.inc

SRC_URI[md5sum] = "1d958f02575d4a19734ee2dd92336157"
SRC_URI[sha256sum] = "5da4d5f40ff8974cf6c724587baa674d7e0593f07b6f6ee896104f11c1be18ec"
