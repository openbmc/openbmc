SUMMARY = "Inline Matplotlib backend for Jupyter"
HOMEPAGE = "https://pypi.org/project/matplotlib-inline/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c2728819a4288030f51c594327977be0"

SRC_URI[sha256sum] = "f41d5ff73c9f5385775d5c0bc13b424535c8402fe70ea8210f93e11f3683993e"

inherit pypi
