inherit pypi setuptools
require python-flask-migrate.inc
