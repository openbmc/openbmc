inherit setuptools3
require python-humanfriendly.inc
