inherit setuptools
require python-setuptools-scm.inc

RDEPENDS_${PN} += "${PYTHON_PN}-argparse"
