inherit setuptools
require python-pycodestyle.inc

RDEPENDS_${PN} += "${PYTHON_PN}-lang"
