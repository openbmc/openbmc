inherit setuptools
require python-inflection.inc

RDEPENDS_${PN} += "${PYTHON_PN}-codecs"
