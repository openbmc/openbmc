inherit pypi setuptools
require python-click.inc

RDEPENDS_${PN} += "${PYTHON_PN}-contextlib"
