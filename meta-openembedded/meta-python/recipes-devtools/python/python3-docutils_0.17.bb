SUMMARY = "Docutils is a modular system for processing documentation into useful formats"
HOMEPAGE = "https://pypi.org/project/docutils/"
SECTION = "devel/python"
LICENSE = "BSD-2-Clause & GPL-2.0 & Python-2.0"
LIC_FILES_CHKSUM = "file://COPYING.txt;md5=836a1950177996968a49ff477a4a61c4"

SRC_URI[sha256sum] = "e2ffeea817964356ba4470efba7c2f42b6b0de0b04e66378507e3e2504bbff4c"

inherit pypi setuptools3
