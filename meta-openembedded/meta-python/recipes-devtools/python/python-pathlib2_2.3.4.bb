inherit pypi setuptools
require python-pathlib2.inc
