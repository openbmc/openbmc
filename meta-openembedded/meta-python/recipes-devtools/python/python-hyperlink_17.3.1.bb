inherit setuptools
require python-hyperlink.inc
