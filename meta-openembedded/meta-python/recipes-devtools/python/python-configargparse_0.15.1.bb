inherit setuptools
require python-configargparse.inc

