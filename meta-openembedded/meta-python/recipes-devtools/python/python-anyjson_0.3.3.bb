inherit setuptools
require python-anyjson.inc
