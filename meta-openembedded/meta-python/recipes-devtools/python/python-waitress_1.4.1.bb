inherit setuptools pypi
require python-waitress.inc
