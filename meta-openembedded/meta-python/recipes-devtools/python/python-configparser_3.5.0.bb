inherit setuptools
require python-configparser.inc
