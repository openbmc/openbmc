require python-pyalsaaudio.inc
inherit pypi setuptools
