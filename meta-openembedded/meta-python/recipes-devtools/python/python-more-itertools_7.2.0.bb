inherit pypi setuptools
require python-more-itertools.inc
