inherit pypi setuptools
require python-tzlocal.inc
