inherit setuptools
require python-pyelftools.inc
