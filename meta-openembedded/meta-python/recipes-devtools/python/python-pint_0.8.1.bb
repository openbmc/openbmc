inherit setuptools
require python-pint.inc
