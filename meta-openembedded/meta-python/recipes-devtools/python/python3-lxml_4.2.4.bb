inherit setuptools3
require python-lxml.inc
CLEANBROKEN = "1"
