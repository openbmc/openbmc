inherit pypi setuptools
require python-flask-wtf.inc
