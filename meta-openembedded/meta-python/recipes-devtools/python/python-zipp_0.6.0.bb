inherit pypi setuptools
require python-zipp.inc
