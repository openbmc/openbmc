inherit setuptools
require python-slip-dbus.inc
