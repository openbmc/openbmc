SUMMARY = "Common type annotations for ethereum python packages."
HOMEPAGE = "https://github.com/ethereum/eth-typing"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3d7bdfe69b1ffbde073ca6e96f5c53f7"

SRC_URI[sha256sum] = "ed52b0c6b049240fd810bc87c8857c7ea39370f060f70b9ca3876285269f2938"

inherit pypi setuptools3
