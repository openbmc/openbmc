inherit pypi setuptools3
require python-pyrsistent.inc
