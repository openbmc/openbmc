inherit setuptools
require python-pymysql.inc
