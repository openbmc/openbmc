inherit setuptools3
require python-sentry-sdk.inc
