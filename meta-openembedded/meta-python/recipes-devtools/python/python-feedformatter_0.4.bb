inherit setuptools
require python-feedformatter.inc
