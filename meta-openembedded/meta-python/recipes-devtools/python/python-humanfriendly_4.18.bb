inherit setuptools
require python-humanfriendly.inc
