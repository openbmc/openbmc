inherit setuptools3
require python-stevedore.inc
