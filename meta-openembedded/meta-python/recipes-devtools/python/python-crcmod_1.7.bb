inherit setuptools
require python-crcmod.inc
