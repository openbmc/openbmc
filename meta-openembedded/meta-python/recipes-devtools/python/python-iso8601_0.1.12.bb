inherit pypi setuptools
require python-iso8601.inc
