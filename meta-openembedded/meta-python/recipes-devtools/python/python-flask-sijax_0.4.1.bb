inherit pypi setuptools
require python-flask-sijax.inc

SRC_URI[sha256sum] = "fb2bf2d4f75408185102195055d75549fee8d9c9e954dca2427186925cdc429f"