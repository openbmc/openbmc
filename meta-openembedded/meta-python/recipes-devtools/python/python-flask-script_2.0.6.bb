inherit pypi setuptools
require python-flask-script.inc
