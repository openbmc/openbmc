inherit setuptools
require python-protobuf.inc
