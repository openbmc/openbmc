inherit pypi setuptools
require python-pathlib2.inc

RDEPENDS_${PN} += "python-scandir \
                   python-misc \
"
