SUMMARY = "Super-fast and clean conversions to numbers."
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d32431d1b650010945da4e078011c8fa"

PYPI_PACKAGE = "fastnumbers"

SRC_URI[sha256sum] = "e092d33f8b95c3171a2fb34e579efe0c54b0290dd7f96ffaa2762437601d90a7"

inherit pypi setuptools3
