inherit setuptools
require python-rfc3986-validator.inc