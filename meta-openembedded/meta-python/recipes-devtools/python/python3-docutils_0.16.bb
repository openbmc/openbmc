SUMMARY = "Docutils is a modular system for processing documentation into useful formats"
HOMEPAGE = "https://pypi.org/project/docutils/"
SECTION = "devel/python"
LICENSE = "BSD-2-Clause & GPL-2.0 & Python-2.0"
LIC_FILES_CHKSUM = "file://COPYING.txt;md5=7a4646907ab9083c826280b19e103106"

SRC_URI[md5sum] = "9ccb6f332e23360f964de72c8ea5f0ed"
SRC_URI[sha256sum] = "7d4e999cca74a52611773a42912088078363a30912e8822f7a3d38043b767573"

inherit pypi setuptools3
