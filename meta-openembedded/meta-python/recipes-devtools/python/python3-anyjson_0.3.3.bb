inherit setuptools3
require python-anyjson.inc
