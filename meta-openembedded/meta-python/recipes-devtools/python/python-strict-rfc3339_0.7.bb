inherit pypi setuptools
require python-strict-rfc3339.inc
