inherit pypi setuptools
require python-xstatic.inc
