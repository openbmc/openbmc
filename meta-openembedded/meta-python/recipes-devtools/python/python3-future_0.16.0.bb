inherit setuptools3
require python-future.inc
