inherit setuptools3
require python-license-expression.inc
