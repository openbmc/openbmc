inherit pypi setuptools
require python-six.inc
