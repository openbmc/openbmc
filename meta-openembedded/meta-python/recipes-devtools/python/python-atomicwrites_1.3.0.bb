inherit pypi setuptools
require python-atomicwrites.inc
