inherit setuptools3
require python-meld3.inc
