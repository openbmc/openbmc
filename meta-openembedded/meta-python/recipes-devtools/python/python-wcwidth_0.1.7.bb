inherit pypi setuptools
require python-wcwidth.inc
