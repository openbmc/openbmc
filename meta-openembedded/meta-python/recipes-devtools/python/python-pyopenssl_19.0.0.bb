require python-pyopenssl.inc
inherit pypi setuptools
