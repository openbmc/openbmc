inherit pypi setuptools3
require python-xstatic-font-awesome.inc
