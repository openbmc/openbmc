inherit pypi setuptools
require python-more-itertools.inc

SRC_URI[md5sum] = "f2ea58aa336ce6c13b7b225b3bbe305d"
SRC_URI[sha256sum] = "38a936c0a6d98a38bcc2d03fdaaedaba9f412879461dd2ceff8d37564d6522e4"

PE = "1"
