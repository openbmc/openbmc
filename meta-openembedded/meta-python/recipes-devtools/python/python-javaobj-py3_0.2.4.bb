require python-javaobj-py3.inc
inherit setuptools
