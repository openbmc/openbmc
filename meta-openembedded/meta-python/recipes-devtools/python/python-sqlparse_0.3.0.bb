inherit setuptools
require python-sqlparse.inc
