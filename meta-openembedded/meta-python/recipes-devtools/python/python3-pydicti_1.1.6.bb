SUMMARY = "Case insensitive derivable dictionary"
HOMEPAGE = "https://github.com/coldfix/pydicti"
LICENSE = "WTFPL"
LIC_FILES_CHKSUM = "file://COPYING;md5=389a9e29629d1f05e115f8f05c283df5"

SRC_URI[sha256sum] = "32eb329de2023c92158ac6c2d67837adf96195f188ba8d768b3248a0218b5a65"

inherit pypi setuptools3
