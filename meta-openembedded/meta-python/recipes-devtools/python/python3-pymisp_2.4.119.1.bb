inherit pypi setuptools3
require python-pymisp.inc
