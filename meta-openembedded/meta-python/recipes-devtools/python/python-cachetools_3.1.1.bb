inherit setuptools
require python-cachetools.inc
