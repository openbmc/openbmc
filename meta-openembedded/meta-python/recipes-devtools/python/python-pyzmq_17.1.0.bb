require python-pyzmq.inc
inherit setuptools
