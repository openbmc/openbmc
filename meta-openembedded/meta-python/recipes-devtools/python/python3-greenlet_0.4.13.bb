inherit distutils3
require python-greenlet.inc
