inherit pypi setuptools
require python-dominate.inc
