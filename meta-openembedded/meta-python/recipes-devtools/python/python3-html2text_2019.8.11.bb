inherit setuptools3
require python-html2text.inc
