inherit setuptools3
require python-protobuf.inc
