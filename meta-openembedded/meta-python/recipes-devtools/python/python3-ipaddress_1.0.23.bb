inherit setuptools3
require python-ipaddress.inc
