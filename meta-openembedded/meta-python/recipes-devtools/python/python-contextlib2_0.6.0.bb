inherit pypi setuptools
require python-contextlib2.inc

