SUMMARY = "Linux watchdog device API for Python."
HOMEPAGE = "https://github.com/timka/watchdogdev"
SECTION = "devel/python"
LICENSE = "Python-2.0"
LIC_FILES_CHKSUM = "file://setup.py;beginline=47;endline=47;md5=ad880087bee2eb64e368954eb7b99bfd"

inherit pypi setuptools3

SRC_URI[sha256sum] = "776ba57a07aef0084466493f40ce20814a29f8914a10ef8177317d02559fd017"
