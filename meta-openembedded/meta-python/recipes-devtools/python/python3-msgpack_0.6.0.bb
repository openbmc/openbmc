require python-msgpack.inc
inherit setuptools3
