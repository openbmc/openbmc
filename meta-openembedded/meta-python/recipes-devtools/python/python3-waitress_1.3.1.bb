inherit setuptools3 pypi
require python-waitress.inc
