require python-pocketsphinx.inc
inherit pypi setuptools3
