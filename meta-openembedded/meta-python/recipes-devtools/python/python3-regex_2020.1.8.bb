SUMMARY = ""
HOMEPAGE = "http://pythonhosted.org/regex"
LICENSE = "PSF"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=3d9edb84b293ab5a9ed5bcaf1b769ab6"

inherit pypi setuptools3

SRC_URI[md5sum] = "73abc3d7e902e94b4281fd2652f5a94f"
SRC_URI[sha256sum] = "d0f424328f9822b0323b3b6f2e4b9c90960b24743d220763c7f07071e0778351"


BBCLASSEXTEND = "native nativesdk"
