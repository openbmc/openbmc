SUMMARY = "Common type annotations for ethereum python packages."
HOMEPAGE = "https://github.com/ethereum/eth-typing"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=bf9691ead96f1163622689e47ce3f366"

SRC_URI[sha256sum] = "92698268be83c75f65a028d47421f7c0aed459be76dd7ce916af166dca8bc53e"

inherit pypi setuptools3
