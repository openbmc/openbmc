inherit setuptools
require python-ujson.inc
