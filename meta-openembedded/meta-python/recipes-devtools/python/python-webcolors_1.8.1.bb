inherit pypi setuptools
require python-webcolors.inc
