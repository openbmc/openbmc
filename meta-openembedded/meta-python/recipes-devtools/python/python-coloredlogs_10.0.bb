inherit setuptools
require python-coloredlogs.inc
