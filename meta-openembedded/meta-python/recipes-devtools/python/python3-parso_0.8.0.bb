SUMMARY = "A Python Parser"
HOMEPAGE = "https://github.com/davidhalter/parso"
AUTHOR = "David Halter <davidhalter88@gmail.com>"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=cbaa2675b2424d771451332a7a69503f"

PYPI_PACKAGE = "parso"

SRC_URI[md5sum] = "ee3592994bfc0d0843790544c1b2b702"
SRC_URI[sha256sum] = "2b6db14759c528d857eeb9eac559c2166b2554548af39f5198bdfb976f72aa64"

inherit setuptools3 pypi
