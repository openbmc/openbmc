inherit pypi setuptools3
require python-rfc3987.inc
