inherit pypi setuptools
require python-visitor.inc
