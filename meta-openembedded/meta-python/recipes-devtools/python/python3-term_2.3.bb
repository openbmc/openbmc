require python-term.inc
inherit pypi setuptools3
