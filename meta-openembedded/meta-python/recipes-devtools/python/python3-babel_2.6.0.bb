inherit setuptools3
require python-babel.inc
