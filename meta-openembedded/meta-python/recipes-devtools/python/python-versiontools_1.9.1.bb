inherit setuptools
require python-versiontools.inc
