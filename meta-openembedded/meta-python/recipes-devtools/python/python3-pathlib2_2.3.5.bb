inherit pypi setuptools3
require python-pathlib2.inc
