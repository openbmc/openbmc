inherit setuptools3
require python-supervisor.inc
