inherit setuptools3
require python-markupsafe.inc
