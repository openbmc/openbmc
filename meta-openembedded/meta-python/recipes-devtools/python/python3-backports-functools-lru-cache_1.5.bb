require python-backports-functools-lru-cache.inc
inherit setuptools3
