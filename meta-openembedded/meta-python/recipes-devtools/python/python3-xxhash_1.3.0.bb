require python-xxhash.inc
inherit pypi setuptools3
