inherit setuptools3
require python-parse.inc
