inherit setuptools
require python-m2crypto.inc
