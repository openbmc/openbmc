inherit pypi setuptools3
require python-werkzeug.inc

RDEPENDS_${PN} += "${PYTHON_PN}-misc"
