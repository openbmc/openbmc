inherit setuptools
require python-parse-type.inc
