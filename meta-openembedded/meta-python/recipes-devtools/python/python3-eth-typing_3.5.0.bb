SUMMARY = "Common type annotations for ethereum python packages."
HOMEPAGE = "https://github.com/ethereum/eth-typing"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3d7bdfe69b1ffbde073ca6e96f5c53f7"

SRC_URI[sha256sum] = "a92f6896896752143a4704c57441eedf7b1f65d5df4b1c20cb802bb4aa602d7e"

inherit pypi setuptools3
