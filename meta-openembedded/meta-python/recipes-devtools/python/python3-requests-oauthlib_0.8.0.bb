require python-requests-oauthlib.inc
inherit pypi setuptools3

