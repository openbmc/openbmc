SUMMARY = "Typing stubs for python-dateutil"
HOMEPAGE = "https://github.com/python/typeshed"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=6;endline=6;md5=c2d9643b4523fdf462545aeb1356ad23"

SRC_URI[sha256sum] = "9706c3b68284c25adffc47319ecc7947e5bb86b3773f843c73906fd598bc176e"

inherit pypi setuptools3
