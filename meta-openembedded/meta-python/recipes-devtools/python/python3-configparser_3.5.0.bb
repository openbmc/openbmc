inherit setuptools3
require python-configparser.inc
