inherit setuptools3
require python-dnspython.inc
