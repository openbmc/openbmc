SUMMARY = "Python expectaton library"
DESCRIPTION = "Minimal but very flexible implementation of the expect pattern"
SECTION = "devel/python"
HOMEPAGE = " https://bitbucket.org/dwt/pyexpect"
LICENSE = "ISC"
LIC_FILES_CHKSUM = "file://README.md;md5=a6aa1e7097aca5955f9a2e1c8b0ce158"

inherit pypi setuptools3

SRC_URI[md5sum] = "7ebc843f015b54d849ac7632eda74e9b"
SRC_URI[sha256sum] = "acaaa6f96de315dc99cac3da810156bf3829d1eb5c49180f00a4fdde82eabc76"
