inherit pypi setuptools
require python-progress.inc
