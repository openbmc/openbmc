SUMMARY = "A Python package that provides customized docstring inheritance schemes between derived classes and their parents."
HOMEPAGE = "https://github.com/rsokl/custom_inherit"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=f910a85a4c3da51edf780f17a7608434"

PYPI_PACKAGE = "custom_inherit"

SRC_URI[sha256sum] = "a0d104847b4cc1ae24e00061fc2e11da8766b019bf4c8c753822347366c8c49f"

inherit pypi setuptools3
