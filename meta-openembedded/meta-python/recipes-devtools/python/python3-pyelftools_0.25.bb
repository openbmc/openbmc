inherit setuptools3
require python-pyelftools.inc
