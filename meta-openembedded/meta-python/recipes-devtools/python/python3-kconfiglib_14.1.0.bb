require python-kconfiglib.inc
inherit pypi setuptools3
