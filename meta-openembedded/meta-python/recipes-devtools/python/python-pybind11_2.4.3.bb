inherit pypi setuptools
require python-pybind11.inc
