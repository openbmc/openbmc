inherit setuptools
require python-pyfirmata.inc

