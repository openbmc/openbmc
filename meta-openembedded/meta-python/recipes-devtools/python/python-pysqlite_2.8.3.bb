inherit setuptools
require python-pysqlite.inc
