inherit setuptools
require python-lrparsing.inc
