inherit pypi setuptools
require python-flask-xstatic.inc
