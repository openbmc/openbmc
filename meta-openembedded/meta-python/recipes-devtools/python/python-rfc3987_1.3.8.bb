inherit pypi setuptools
require python-rfc3987.inc
