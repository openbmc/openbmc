inherit setuptools
require python-pluggy.inc
