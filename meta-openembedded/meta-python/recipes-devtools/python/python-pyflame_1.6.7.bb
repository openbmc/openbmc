require python-pyflame.inc

# v1.6.7
SRCREV = "c151d2f34737f28a1f5266a003b2b0720bbd9f96"
