require python-twofish.inc
inherit setuptools
