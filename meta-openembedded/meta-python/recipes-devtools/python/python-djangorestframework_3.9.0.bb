require python-djangorestframework.inc
inherit setuptools