inherit setuptools
require python-pytz.inc
