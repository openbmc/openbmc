inherit setuptools3
require python-automat.inc
