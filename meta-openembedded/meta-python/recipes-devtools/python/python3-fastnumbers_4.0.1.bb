SUMMARY = "Super-fast and clean conversions to numbers."
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=58db8ac9e152dd9b700f4d39ff40a31a"

PYPI_PACKAGE = "fastnumbers"

SRC_URI[sha256sum] = "3e7d74b1debb44c4803c0fea59a63d0785d6a26ebcb902e2262b3c3fba81b400"

inherit pypi setuptools3
