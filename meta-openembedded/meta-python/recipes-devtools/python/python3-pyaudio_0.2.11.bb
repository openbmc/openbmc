require python-pyaudio.inc
inherit pypi setuptools3
