inherit setuptools
require python-jsonpatch.inc

RDEPENDS_${PN} += "${PYTHON_PN}-re"
