inherit setuptools3
require python-robotframework.inc
