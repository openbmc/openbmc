SUMMARY = "collections.abc from Python 3.5"
DESCRIPTION = "A backport of recent additions to the 'collections.abc' module"
LICENSE = "PSF"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dd98d01d471fac8d8dbdd975229dba03"

PYPI_PACKAGE = "backports_abc"

SRC_URI[md5sum] = "7d1936ec183a3586290adf60f6f96764"
SRC_URI[sha256sum] = "033be54514a03e255df75c5aee8f9e672f663f93abb723444caec8fe43437bde"

inherit pypi setuptools
