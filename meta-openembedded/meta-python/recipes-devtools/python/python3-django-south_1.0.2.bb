require python-django-south.inc
inherit setuptools3
