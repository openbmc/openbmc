inherit setuptools
require python-attr.inc
