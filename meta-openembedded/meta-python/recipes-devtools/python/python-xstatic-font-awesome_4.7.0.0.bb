inherit pypi setuptools
require python-xstatic-font-awesome.inc
