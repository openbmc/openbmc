inherit setuptools3
require python-aiohttp.inc
