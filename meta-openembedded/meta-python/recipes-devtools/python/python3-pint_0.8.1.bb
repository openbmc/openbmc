inherit setuptools3
require python-pint.inc
