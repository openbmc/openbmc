inherit setuptools
require python-pyiface.inc