inherit pypi setuptools
require python-pysocks.inc
