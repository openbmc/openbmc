inherit pypi setuptools
require python-packaging.inc
