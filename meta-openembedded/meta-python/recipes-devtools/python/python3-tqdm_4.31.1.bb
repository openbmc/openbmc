inherit setuptools3
require python-tqdm.inc
