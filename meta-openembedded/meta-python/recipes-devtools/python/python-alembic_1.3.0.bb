inherit pypi setuptools
require python-alembic.inc
