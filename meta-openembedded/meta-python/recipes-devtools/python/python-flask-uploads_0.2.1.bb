inherit pypi setuptools
require python-flask-uploads.inc
