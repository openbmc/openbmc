inherit setuptools
require python-chardet.inc

RDEPENDS_${PN} += "${PYTHON_PN}-argparse"
