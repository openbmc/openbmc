inherit setuptools3
require python-ipy.inc
