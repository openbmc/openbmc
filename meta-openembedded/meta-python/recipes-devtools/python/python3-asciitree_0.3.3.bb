SUMMARY = "Draws ASCII trees."
HOMEPAGE = "http://github.com/mbr/asciitree"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a985ccb0df374f2a8cab75010bf8db73"

SRC_URI[sha256sum] = "4aa4b9b649f85e3fcb343363d97564aa1fb62e249677f2e18a96765145cc0f6e"

inherit pypi setuptools3
