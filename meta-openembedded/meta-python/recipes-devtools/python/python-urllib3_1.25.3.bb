inherit pypi setuptools
require python-urllib3.inc
