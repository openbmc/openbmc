inherit setuptools3
require python-intervals.inc
