inherit pypi setuptools
require python-editor.inc
