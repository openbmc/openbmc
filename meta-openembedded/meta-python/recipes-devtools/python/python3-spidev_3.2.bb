inherit setuptools3
require python-spidev.inc
