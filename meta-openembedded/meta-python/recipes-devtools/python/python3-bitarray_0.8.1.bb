inherit setuptools3
require python-bitarray.inc
