inherit pypi setuptools3
require python-tzlocal.inc
