inherit setuptools
require python-dnspython.inc
