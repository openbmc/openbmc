inherit setuptools
require python-pycurl.inc
