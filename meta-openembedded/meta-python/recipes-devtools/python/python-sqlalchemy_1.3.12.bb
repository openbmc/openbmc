inherit setuptools
require python-sqlalchemy.inc
