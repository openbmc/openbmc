inherit pypi setuptools3
require python-progress.inc
