inherit pypi setuptools3
require python-pybind11.inc
