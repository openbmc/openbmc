SUMMARY = "Inline Matplotlib backend for Jupyter"
HOMEPAGE = "https://pypi.org/project/matplotlib-inline/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d4692a0eb42ca54892399db2cb35e61e"

SRC_URI[sha256sum] = "f887e5f10ba98e8d2b150ddcf4702c1e5f8b3a20005eb0f74bfdbd360ee6f304"

inherit pypi
