inherit setuptools3
require python-isodate.inc
