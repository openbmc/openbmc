require python-pytest-helpers-namespace.inc

inherit setuptools

RDEPENDS_${PN} += " \
    python-pytest \
    "
