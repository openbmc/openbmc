SUMMARY = "Case insensitive derivable dictionary"
HOMEPAGE = "https://github.com/coldfix/pydicti"
LICENSE = "WTFPL"
LIC_FILES_CHKSUM = "file://COPYING;md5=389a9e29629d1f05e115f8f05c283df5"

SRC_URI[sha256sum] = "63e0756ff27a335e92916ff40be589a21a58894b3a93099edf0f3cbf695690dc"

inherit pypi setuptools3
