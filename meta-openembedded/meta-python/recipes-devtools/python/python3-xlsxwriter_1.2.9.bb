inherit setuptools3
require python-xlsxwriter.inc

SRC_URI[md5sum] = "20f8b7df7f1705fa2f7ac3f84789d2ca"
SRC_URI[sha256sum] = "828b3285fc95105f5b1946a6a015b31cf388bd5378fdc6604e4d1b7839df2e77"
