inherit pypi setuptools3
require python-flask-migrate.inc
