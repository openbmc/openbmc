inherit setuptools
require python-mako.inc
