inherit setuptools3
require python-pyperclip.inc
