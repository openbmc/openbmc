inherit setuptools
require python-pika.inc
