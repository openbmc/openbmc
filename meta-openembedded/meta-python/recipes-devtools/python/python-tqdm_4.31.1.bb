inherit setuptools
require python-tqdm.inc
