SUMMARY = "An efficient and agile neural network intent parser. Padatious is a core component of Mycroft AI."
HOMEPAGE = "https://github.com/MycroftAI/padatious"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://README.md;md5=77baec496a458dd0e0fc4ca64cd305bc"

SRC_URI[md5sum] = "1f53967a1633baa8fd48f11139808a33"
SRC_URI[sha256sum] = "3c235942ff4151a3c36536fd776bd8a6d4d57c97046723d2fa80a89b34faac1f"

inherit pypi setuptools3
