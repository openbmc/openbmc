inherit setuptools3
require python-grpcio.inc
