SUMMARY = "Case insensitive derivable dictionary"
HOMEPAGE = "https://github.com/coldfix/pydicti"
LICENSE = "WTFPL"
LIC_FILES_CHKSUM = "file://COPYING;md5=389a9e29629d1f05e115f8f05c283df5"

SRC_URI[md5sum] = "b02ed35da91e400f1f17a57ab02ba06b"
SRC_URI[sha256sum] = "eea50576baa751a9b6b862f09f081c47d557e0298623ca8742851da72b00eec4"

inherit pypi setuptools3
