inherit pypi setuptools3
require python-jinja2.inc
