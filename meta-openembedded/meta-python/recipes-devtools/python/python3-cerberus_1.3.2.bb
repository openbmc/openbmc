# The PyPI package uses a capital letter so we have to specify this explicitly
PYPI_PACKAGE = "Cerberus"

inherit pypi setuptools3

SUMMARY = "Lightweight, extensible schema and data validation tool for Python dictionaries."
LICENSE = "ISC"
LIC_FILES_CHKSUM = "file://LICENSE;md5=48f8e9432d0dac5e0e7a18211a0bacdb"

SRC_URI[md5sum] = "6e648b38b468617a06745d1e8a96c848"
SRC_URI[sha256sum] = "302e6694f206dd85cb63f13fd5025b31ab6d38c99c50c6d769f8fa0b0f299589"
