inherit setuptools
require python-rfc3339-validator.inc