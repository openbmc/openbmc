inherit setuptools
require python-flask-restful.inc
