inherit setuptools3
require python-pandas.inc
