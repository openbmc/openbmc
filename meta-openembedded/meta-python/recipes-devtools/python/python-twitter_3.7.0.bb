require python-twitter.inc
inherit pypi setuptools

