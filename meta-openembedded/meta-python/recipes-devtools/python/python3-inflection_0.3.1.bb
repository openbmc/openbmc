inherit setuptools3
require python-inflection.inc
