inherit setuptools
require python-pyparsing.inc
