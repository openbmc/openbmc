inherit setuptools
require python-future.inc
