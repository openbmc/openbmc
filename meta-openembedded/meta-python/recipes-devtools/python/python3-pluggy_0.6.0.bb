inherit setuptools3
require python-pluggy.inc
