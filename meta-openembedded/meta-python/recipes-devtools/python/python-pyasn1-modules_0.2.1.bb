require python-pyasn1-modules.inc
inherit setuptools
