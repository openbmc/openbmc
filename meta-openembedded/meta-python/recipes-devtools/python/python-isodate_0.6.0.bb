inherit setuptools
require python-isodate.inc
