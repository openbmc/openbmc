inherit setuptools3
require python-pyperf.inc

RDEPENDS_${PN} += "${PYTHON_PN}-misc"
