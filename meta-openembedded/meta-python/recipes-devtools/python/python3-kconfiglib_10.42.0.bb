require python-kconfiglib-${PV}.inc
inherit pypi setuptools3
