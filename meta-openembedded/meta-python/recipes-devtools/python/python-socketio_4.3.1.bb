inherit setuptools
require python-socketio.inc
