inherit pypi setuptools3
require python-pymongo.inc
