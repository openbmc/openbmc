inherit setuptools3
require python-flask-restful.inc
