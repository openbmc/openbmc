SUMMARY = "unittest-based test runner with Ant/JUnit like XML reporting"
HOMEPAGE = "https://github.com/pycontribs/xmlrunner"
LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=fa964f202b6ae067ed5828fe43c77c1a"

SRC_URI[md5sum] = "7b0b152ed2d278516aedbc0cac22dfb3"
SRC_URI[sha256sum] = "5a6113d049eca7646111ee657266966e5bbfb0b5ceb2e83ee0772e16d7110f39"

inherit pypi setuptools3
