inherit pypi setuptools3
require python-more-itertools.inc

SRC_URI[md5sum] = "55e7e0a5eabc5a57bc8353c65c6f9965"
SRC_URI[sha256sum] = "b1ddb932186d8a6ac451e1d95844b382f55e12686d51ca0c68b6f61f2ab7a507"
