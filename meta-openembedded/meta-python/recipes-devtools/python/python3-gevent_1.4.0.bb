require python-gevent.inc
inherit setuptools3
