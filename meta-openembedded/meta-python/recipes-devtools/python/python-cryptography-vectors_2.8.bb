inherit pypi setuptools
require python-cryptography-vectors.inc
