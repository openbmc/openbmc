require python-pyyaml.inc
inherit setuptools
