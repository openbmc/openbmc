require python-netifaces.inc
inherit setuptools
