inherit pypi setuptools3
require python-pytest.inc

ALTERNATIVE_PRIORITY = "100"
