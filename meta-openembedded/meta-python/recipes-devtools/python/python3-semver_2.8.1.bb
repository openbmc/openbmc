inherit setuptools3
require python-semver.inc
