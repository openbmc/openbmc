inherit pypi setuptools3
require python-jsonschema.inc
