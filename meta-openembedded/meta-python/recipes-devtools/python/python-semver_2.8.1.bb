inherit setuptools
require python-semver.inc
