inherit setuptools
require python-bitarray.inc
