inherit setuptools
require python-pyperf.inc

RDEPENDS_${PN} += "${PYTHON_PN}-statistics"
