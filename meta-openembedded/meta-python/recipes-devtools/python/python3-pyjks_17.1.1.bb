require python-pyjks.inc
inherit setuptools3
