SUMMARY = ""
HOMEPAGE = "http://pythonhosted.org/regex"
LICENSE = "PSF"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=51cb124129fa4d157b4aebb77df73629"

inherit pypi setuptools3

SRC_URI[md5sum] = "d31ec392ab75b894404d8db76dacd191"
SRC_URI[sha256sum] = "587b62d48ca359d2d4f02d486f1f0aa9a20fbaf23a9d4198c4bed72ab2f6c849"


BBCLASSEXTEND = "native nativesdk"
