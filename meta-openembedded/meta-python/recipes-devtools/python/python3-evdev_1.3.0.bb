inherit pypi setuptools3
require python-evdev.inc

