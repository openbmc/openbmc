inherit setuptools
require python-ipaddress.inc
