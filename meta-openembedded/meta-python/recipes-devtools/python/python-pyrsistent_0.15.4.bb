inherit pypi setuptools
require python-pyrsistent.inc
