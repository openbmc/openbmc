inherit setuptools3
require python-wrapt.inc
