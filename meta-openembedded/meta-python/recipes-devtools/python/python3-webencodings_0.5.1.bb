inherit setuptools3
require python-webencodings.inc
