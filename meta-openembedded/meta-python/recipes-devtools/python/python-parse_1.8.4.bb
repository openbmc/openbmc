inherit setuptools
require python-parse.inc
