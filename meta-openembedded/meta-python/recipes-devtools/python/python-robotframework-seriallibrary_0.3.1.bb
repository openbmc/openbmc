inherit pypi setuptools
require python-robotframework-seriallibrary.inc
