inherit pypi setuptools
require python-wtforms.inc
