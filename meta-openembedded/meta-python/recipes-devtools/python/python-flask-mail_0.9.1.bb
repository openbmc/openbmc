inherit pypi setuptools
require python-flask-mail.inc
