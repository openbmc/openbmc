SUMMARY = "Case insensitive derivable dictionary"
HOMEPAGE = "https://github.com/coldfix/pydicti"
LICENSE = "WTFPL"
LIC_FILES_CHKSUM = "file://COPYING;md5=389a9e29629d1f05e115f8f05c283df5"

SRC_URI[sha256sum] = "32d59407b3229b22702910bd10f53d46c330481b5aea7cce076630d661be9d1e"

inherit pypi setuptools3
