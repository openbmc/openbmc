inherit setuptools
require python-stevedore.inc
