require python-systemd.inc
inherit setuptools3
