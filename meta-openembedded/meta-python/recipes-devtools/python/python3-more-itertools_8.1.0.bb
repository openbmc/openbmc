inherit pypi setuptools3
require python-more-itertools.inc

SRC_URI[md5sum] = "a552b06cec1bdf01d60f952dbcc9a021"
SRC_URI[sha256sum] = "c468adec578380b6281a114cb8a5db34eb1116277da92d7c46f904f0b52d3288"
