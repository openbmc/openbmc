inherit setuptools
require python-configparser.inc
RDEPENDS_${PN} += "python-pkgutil"
