inherit pypi setuptools3
require python-packaging.inc
