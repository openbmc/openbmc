inherit setuptools3
require python-m2crypto.inc
