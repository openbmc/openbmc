inherit setuptools3
require python-rfc3986-validator.inc