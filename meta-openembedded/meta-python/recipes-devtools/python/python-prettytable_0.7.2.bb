inherit setuptools
require python-prettytable.inc

