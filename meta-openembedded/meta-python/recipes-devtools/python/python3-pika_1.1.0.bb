inherit setuptools3
require python-pika.inc
