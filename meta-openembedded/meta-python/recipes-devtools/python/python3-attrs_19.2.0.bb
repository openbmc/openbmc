inherit setuptools3
require python-attrs.inc
