require python-pycryptodome.inc
inherit setuptools3
