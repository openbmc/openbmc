inherit setuptools
require python-ipy.inc
