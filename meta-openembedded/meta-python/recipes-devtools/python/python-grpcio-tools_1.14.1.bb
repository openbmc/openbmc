inherit setuptools
require python-grpcio-tools.inc
