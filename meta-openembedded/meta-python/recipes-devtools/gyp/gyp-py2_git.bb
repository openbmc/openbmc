inherit setuptools
require gyp.inc
