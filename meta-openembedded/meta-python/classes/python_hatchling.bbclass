inherit python_pep517 python3native python3-dir setuptools3-base

DEPENDS += "python3-hatchling-native"

PEP517_BUILD_API = "hatchling.build"
