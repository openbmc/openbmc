require  meta-python-image-base.bb

SUMMARY = "meta-python ptest test image"

IMAGE_INSTALL += "packagegroup-meta-python3-ptest"
