require meta-python-image-ptest-all.bb

DESCRIPTION = "Recipe to trigger execution of all fast meta-python ptest images."

PTESTS_META_PYTHON = "${PTESTS_FAST_META_PYTHON}"

