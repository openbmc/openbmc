require recipes-core/images/core-image-base.bb

SUMMARY = "meta-python build test image"

IMAGE_INSTALL += "packagegroup-meta-python3"
