# networkmanager-applet requires glib support
PACKAGECONFIG_append = " glib"

