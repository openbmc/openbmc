require  meta-filesystems-image-base.bb

IMAGE_INSTALL += "packagegroup-meta-filesystems"
