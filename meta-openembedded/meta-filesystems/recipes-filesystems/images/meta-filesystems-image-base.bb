SUMMARY = "meta-filesystems build test image"

IMAGE_INSTALL = "packagegroup-core-boot"

LICENSE = "MIT"

inherit core-image
