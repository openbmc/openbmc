SUMMARY = "A calculator plugin for the Xfce panel"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-calculator-plugin"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=909430f63fddd63f120ba29e8979f65c"

inherit xfce-panel-plugin gtk-icon-cache

SRC_URI[md5sum] = "1ae192a69834ee2f51f34a0a981181f4"
SRC_URI[sha256sum] = "7b50ab947ab058e1c079113e7f0f8b38ef242fec36ec9f31bb4e3c19cb3f9de9"
