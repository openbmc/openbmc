SUMMARY = "Panel plugin displaying stats from a wireless lan interface"
HOMEPAGE = "https://goodies.xfce.org/projects/panel-plugins/xfce4-wavelan-plugin"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://COPYING;md5=e1e5872df9c5cf1a23f16493d9104920"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "e4e3d5240297253d242464e77f6145df"
SRC_URI[sha256sum] = "f41f81ea063ae3c7d7904e1ee647a6b5efafc7436f47caed662ee417038eed17"
