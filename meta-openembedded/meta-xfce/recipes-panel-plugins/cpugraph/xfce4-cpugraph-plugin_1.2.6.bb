SUMMARY = "Panel plugin with graphical representation of the cpu frequency"
HOMEPAGE = "https://goodies.xfce.org/projects/panel-plugins/xfce4-cpugraph-plugin"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=415654f59d8fa70fe4eac2c3f86c8f5e"

inherit xfce-panel-plugin

SRC_URI[sha256sum] = "773246f57c1824a85468d4119c17aeb07170ed1ebace8fa406c7fbcf5b47af99"
