# Just a comment line to avoid PAK archive (application/x-pak)
PACKAGECONFIG_append = " thunar"
