require u-boot-common-aspeed-sdk.inc
