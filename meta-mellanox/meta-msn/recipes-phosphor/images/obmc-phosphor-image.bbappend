OBMC_IMAGE_EXTRA_INSTALL_append = " mlx-ipmid"
