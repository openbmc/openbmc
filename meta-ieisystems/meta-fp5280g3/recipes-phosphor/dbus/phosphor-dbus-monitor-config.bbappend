PHOSPHOR_DBUS_MONITOR_CONFIGS:append = " events-policy"
