PACKAGECONFIG:append = " oem-ibm"
