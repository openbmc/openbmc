EXTRA_OEMESON:append = " \
    -Dredfish-new-powersubsystem-thermalsubsystem=enabled \
    "
