FILESEXTRAPATHS:prepend:x11spi := "${THISDIR}/${BPN}:"
