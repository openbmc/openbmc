FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI += " file://pam.d/common-password \
            "
