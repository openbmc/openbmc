FILESEXTRAPATHS_prepend_zaius := "${THISDIR}/${PN}:"
SRC_URI_append_zaius = " file://0001-board-aspeed-Add-reset_phy-for-Zaius.patch"
