RDEPENDS:${PN}:append:zaius = ' avsbus-control vcs-control'
