PACKAGECONFIG:append:zaius = " 7seg"
