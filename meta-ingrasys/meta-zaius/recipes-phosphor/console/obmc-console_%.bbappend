FILESEXTRAPATHS:prepend:zaius := "${THISDIR}/${PN}:"
