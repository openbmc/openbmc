FILESEXTRAPATHS:append:zaius := ":${THISDIR}/${BPN}"
SRC_URI:append:zaius = " file://powerpolicy-default-ALWAYS_POWER_ON.override.yml"
