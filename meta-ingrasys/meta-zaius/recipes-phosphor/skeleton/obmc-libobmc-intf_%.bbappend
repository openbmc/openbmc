FILESEXTRAPATHS:prepend:zaius := "${THISDIR}/${BPN}:"
