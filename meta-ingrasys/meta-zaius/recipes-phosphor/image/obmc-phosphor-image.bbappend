OBMC_IMAGE_EXTRA_INSTALL:append:zaius = " mboxd"
