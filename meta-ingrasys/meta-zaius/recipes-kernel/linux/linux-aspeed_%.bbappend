FILESEXTRAPATHS:prepend:zaius := "${THISDIR}/${BPN}:"
SRC_URI:append:zaius = " file://zaius.cfg"
