PACKAGECONFIG:append = " verify_signature"
