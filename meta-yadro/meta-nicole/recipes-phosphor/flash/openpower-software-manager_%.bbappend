PACKAGECONFIG:append = " verify_pnor_signature"
