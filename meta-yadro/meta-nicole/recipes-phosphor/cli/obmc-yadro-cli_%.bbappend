RDEPENDS:${PN}:append = " \
    obmc-yadro-backup \
    obmc-yadro-lsinventory \
    op-proc-control \
    openpower-esel-parser \
    phosphor-debug-collector \
    phosphor-led-manager \
    phosphor-objmgr \
    phosphor-state-manager \
"
