FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-Stop-and-send-SRESET-for-one-thread-only.patch"
