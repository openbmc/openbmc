RDEPENDS:${PN}:append = " avsbus-control"
