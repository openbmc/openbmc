u-boot-aspeed_%.bbappend