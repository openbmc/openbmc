FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
