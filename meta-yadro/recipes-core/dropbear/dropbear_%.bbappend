FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
