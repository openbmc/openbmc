PACKAGECONFIG = " \
    adcsensor \
    cpusensor \
    fansensor \
    hwmontempsensor \
    intrusionsensor \
    ipmbsensor \
    psusensor \
"
