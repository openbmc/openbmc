PACKAGECONFIG:remove = " cpuinfo"
