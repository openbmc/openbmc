SYSTEMD_SERVICE_${PN} += "first-boot-set-mac@eth0.service"
