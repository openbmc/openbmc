EXTRA_OECONF_append = " --enable-i2c-occ"
