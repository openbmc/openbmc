OBMC_IMAGE_EXTRA_INSTALL_append = " mboxd first-boot-set-mac"
