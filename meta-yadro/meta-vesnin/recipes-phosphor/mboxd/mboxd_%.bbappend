MBOXD_FLASH_SIZE = "64M"
