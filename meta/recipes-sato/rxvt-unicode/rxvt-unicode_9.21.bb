require rxvt-unicode.inc

LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504 \
                    file://src/main.C;beginline=1;endline=31;md5=7dac0395806570856e037f98aba8513b"

SRC_URI[md5sum] = "a9a06c608258c5fd247c3725d8f44582"
SRC_URI[sha256sum] = "75270ed72bc5895a64a1d7392bf45a622204192371c3965bd3dd978dc088956b"
