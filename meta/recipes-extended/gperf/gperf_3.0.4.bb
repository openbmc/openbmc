require gperf.inc


SRC_URI[md5sum] = "c1f1db32fb6598d6a93e6e88796a8632"
SRC_URI[sha256sum] = "767112a204407e62dbc3106647cf839ed544f3cf5d0f0523aaa2508623aad63e"
