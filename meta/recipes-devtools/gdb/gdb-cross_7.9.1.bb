require gdb-cross.inc
require gdb-${PV}.inc

SRC_URI += "file://0001-make-man-install-relative-to-DESTDIR.patch"
