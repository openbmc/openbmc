SUMMARY = "Target packages for Qt Embedded SDK"

PR = "r7"

QTLIBPREFIX = "-embedded"

require packagegroup-qt-toolchain-target.inc
