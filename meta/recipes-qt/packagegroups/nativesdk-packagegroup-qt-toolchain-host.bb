require nativesdk-packagegroup-qt-toolchain-host.inc

SUMMARY = "Host packages for Qt SDK"
