# Qt Embedded toolchain
PR = "r6"
QTNAME = "qte"
QT_DIR_NAME = "qtopia"

require meta-toolchain-qt.inc
