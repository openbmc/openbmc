# Qt toolchain
QTNAME = "qt"
QT_DIR_NAME = "qt4"

require meta-toolchain-qt.inc
