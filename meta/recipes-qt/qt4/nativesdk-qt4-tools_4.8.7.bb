require nativesdk-qt4-tools.inc

SRC_URI += "file://0009-qmake-fix-source-file-references-in-qmake.pri.patch"

SRC_URI[md5sum] = "d990ee66bf7ab0c785589776f35ba6ad"
SRC_URI[sha256sum] = "e2882295097e47fe089f8ac741a95fef47e0a73a3f3cdf21b56990638f626ea0"
