inherit gnomebase gtk-icon-cache gconf mime
