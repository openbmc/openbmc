require clutter-gtk-1.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=7fbc338309ac38fefcd64b04bb903e34"

SRC_URI[archive.md5sum] = "79dc3d7a8645f87d83a9ccca8a08aa8e"
SRC_URI[archive.sha256sum] = "9440a68600f58d00fe0af35383738943e8ead9907f4cf507a102d96822434a28"
