require dropbear.inc

SRC_URI[md5sum] = "2ccc0a2f3e37ca221db12c5af6a88137"
SRC_URI[sha256sum] = "376214169c0e187ee9f48ae1a99b3f835016ad5b98ede4bfd1cf581deba783af"

