require readline.inc

SRC_URI += "file://readline63-003 \
            file://readline-dispatch-multikey.patch"

SRC_URI[archive.md5sum] = "33c8fb279e981274f485fd91da77e94a"
SRC_URI[archive.sha256sum] = "56ba6071b9462f980c5a72ab0023893b65ba6debb4eeb475d7a563dc65cafd43"

