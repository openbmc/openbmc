SUMMARY = "Dropbear SSH client/server"
LICENSE = "MIT"
PR = "r1"

inherit packagegroup

RDEPENDS_${PN} = "dropbear"
