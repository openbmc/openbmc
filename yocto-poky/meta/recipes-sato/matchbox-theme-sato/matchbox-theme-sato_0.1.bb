require matchbox-theme-sato.inc

PR = "r1"

SRC_URI = "http://pokylinux.org/releases/sato/matchbox-theme-sato-0.1.tar.gz"

SRC_URI[md5sum] = "72ae272ef7803141a3dcb69e670cff97"
SRC_URI[sha256sum] = "5b59f9646edbfb907a309332db3bd6fa7080dc1fe24df549480cfae7d974a3fb"
