require recipes-devtools/gcc/gcc-${PV}.inc
require libgcc.inc
