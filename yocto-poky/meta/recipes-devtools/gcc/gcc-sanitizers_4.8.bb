require recipes-devtools/gcc/gcc-${PV}.inc
require gcc-sanitizers.inc
