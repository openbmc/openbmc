require pseudo.inc

SRCREV = "e795df44a90a426a76b790f1b2774f3046a8fc31"
PV = "1.7.2+git${SRCPV}"

DEFAULT_PREFERENCE = "-1"

SRC_URI = "git://git.yoctoproject.org/pseudo"

S = "${WORKDIR}/git"

