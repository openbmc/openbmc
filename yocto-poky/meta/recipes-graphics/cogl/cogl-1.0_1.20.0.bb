require cogl-1.0.inc

SRC_URI += "file://cogl-framebuffer-gl-Work-again-on-GLESv2.patch"

LIC_FILES_CHKSUM = "file://COPYING;md5=1b1a508d91d25ca607c83f92f3e31c84"
SRC_URI[archive.md5sum] = "5b28897194d9ff76a574a9493d1f7ee0"
SRC_URI[archive.sha256sum] = "729e35495829e7d31fafa3358e47b743ba21a2b08ff9b6cd28fb74c0de91192b"

