require cogl-1.0.inc

SRC_URI += "file://test-backface-culling.c-fix-may-be-used-uninitialize.patch"

LIC_FILES_CHKSUM = "file://COPYING;md5=1b1a508d91d25ca607c83f92f3e31c84"
SRC_URI[archive.md5sum] = "ab684ec96848d79d22757fb3064820c8"
SRC_URI[archive.sha256sum] = "689dfb5d14fc1106e9d2ded0f7930dcf7265d0bc84fa846b4f03941633eeaa91"
