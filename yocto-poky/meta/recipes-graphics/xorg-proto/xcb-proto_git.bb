DEFAULT_PREFERENCE = "-1"

include xcb-proto.inc
SRCREV = "d81ca233e98be8fa59e8c90d262c0516944c5a66"
PV = "1.2+gitr${SRCPV}"
PR = "r4"

SRC_URI = "git://anongit.freedesktop.org/git/xcb/proto"
S = "${WORKDIR}/git"
