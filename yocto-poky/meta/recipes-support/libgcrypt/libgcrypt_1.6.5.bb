require libgcrypt.inc

SRC_URI[md5sum] = "f24fcb684932d4b5ed85f2f05cb1d9f8"
SRC_URI[sha256sum] = "202bf109ccf2d614565c849f3e5687b94cde972167b35261e094252367627bc6"
