inherit autotools

