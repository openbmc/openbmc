require dbus-glib.inc

SRC_URI[md5sum] = "5497d2070709cf796f1878c75a72a039"
SRC_URI[sha256sum] = "bfc1f1a82bfc3ec3ecafe04d0e87bab7e999f50dce4f4a34d0b89caf6bd821f6"
