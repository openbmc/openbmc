require dropbear.inc

SRC_URI[md5sum] = "7664ac10f7cc2301c530eb80c756fc5d"
SRC_URI[sha256sum] = "55ea7c1e904ffe4b1cdbe1addca8291a2533d7d285fd22ac33608e9502a62446"
