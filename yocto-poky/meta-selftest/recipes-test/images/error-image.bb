SUMMARY = "An image that includes the error recipe and will therefore fail"
DESCRIPTION = "This generates an error. Not currently used by oe-selftest"

IMAGE_INSTALL = "error"

IMAGE_LINGUAS = " "

inherit core-image
