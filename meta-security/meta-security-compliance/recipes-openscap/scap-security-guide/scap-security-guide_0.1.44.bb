SUMARRY = "SCAP content for various platforms, upstream version"

SRCREV = "8cb2d0f351faff5440742258782281164953b0a6"
SRC_URI = "git://github.com/ComplianceAsCode/content.git"

DEFAULT_PREFERENCE = "-1"

require scap-security-guide.inc
