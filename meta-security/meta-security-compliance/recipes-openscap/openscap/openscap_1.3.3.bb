SUMARRY = "NIST Certified SCAP 1.2 toolkit"

require openscap.inc

SRCREV = "0cb55c55af6be9934d6fd0caf4563b206f289732"
SRC_URI = "git://github.com/OpenSCAP/openscap.git;branch=maint-1.3 \
"

DEFAULT_PREFERENCE = "-1"
