SUMARRY = "NIST Certified SCAP 1.2 toolkit"

require openscap.inc

SRCREV = "3a4c635691380fa990a226acc8558db35d7ebabc"
SRC_URI = "git://github.com/OpenSCAP/openscap.git;branch=maint-1.3 \
"

DEFAULT_PREFERENCE = "-1"
