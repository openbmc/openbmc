CPE_NAME="cpe:/o:openembedded:nodistro:0"
