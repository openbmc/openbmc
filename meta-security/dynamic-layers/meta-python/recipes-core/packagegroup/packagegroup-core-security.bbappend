

RDEPENDS:packagegroup-security-utils += "\
    python3-privacyidea \
    python3-fail2ban \
    "

RDEPENDS:packagegroup-meta-security-ptest-packages += "\
    python3-fail2ban-ptest \
    "
