inherit setuptools
require python-fail2ban.inc

RDEPENDS_${PN}-ptest = "python python-modules python-fail2ban"
