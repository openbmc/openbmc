FILESEXTRAPATHS:prepend:s2600wf := "${THISDIR}/${PN}:"
