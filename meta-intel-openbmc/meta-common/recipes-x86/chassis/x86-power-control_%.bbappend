# Use PLT_RST to detect warm resets
EXTRA_OECMAKE:intel += "-DUSE_PLT_RST=ON"
