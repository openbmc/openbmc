FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
 file://intel-obmc.cfg \
"
