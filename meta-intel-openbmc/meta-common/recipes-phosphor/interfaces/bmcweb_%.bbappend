PACKAGECONFIG:append = " \
    redfish-cpu-log \
"

