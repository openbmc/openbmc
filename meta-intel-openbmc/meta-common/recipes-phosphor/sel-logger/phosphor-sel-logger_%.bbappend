PACKAGECONFIG:append:intel = " log-threshold log-alarm"
