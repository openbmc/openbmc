PHOSPHOR_MAPPER_CONFIGS:append:intel = " intel-dbus-interfaces-mapper-config-native"
