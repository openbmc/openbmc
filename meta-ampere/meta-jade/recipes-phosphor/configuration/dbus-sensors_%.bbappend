PACKAGECONFIG:remove = " intelcpusensor ipmbsensor"
