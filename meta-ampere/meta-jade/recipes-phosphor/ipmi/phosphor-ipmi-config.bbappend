FILESEXTRAPATHS:append:mtjade := "${THISDIR}/${PN}:"
