FILESEXTRAPATHS_append_mtjade := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Ampere-password-policy-webui.patch \
            file://0002-Correct-the-power-limit-value.patch \
            "
