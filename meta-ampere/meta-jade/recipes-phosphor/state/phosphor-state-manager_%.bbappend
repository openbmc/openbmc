PACKAGECONFIG:remove = "no-warm-reboot"
