FILESEXTRAPATHS_append_mtjade := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Correct-the-power-button-press-time.patch"
