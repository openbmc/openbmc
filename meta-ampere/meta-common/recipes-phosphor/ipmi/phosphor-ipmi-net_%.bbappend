FILESEXTRAPATHS:append := "${THISDIR}/${BPN}:"

PACKAGECONFIG:remove = "rmcp-ping"
