FILESEXTRAPATHS:append := "${THISDIR}/${BPN}:"
