EXTRA_OECMAKE += "-DLONG_PRESS_TIME_MS=5000"
