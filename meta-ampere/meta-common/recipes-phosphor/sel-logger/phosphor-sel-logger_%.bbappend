PACKAGECONFIG_append = " log-threshold"
