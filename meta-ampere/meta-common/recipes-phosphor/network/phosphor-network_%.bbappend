PACKAGECONFIG_append = " nic-ethtool"
