FILESEXTRAPATHS:append := "${THISDIR}/${BPN}:"

