FILESEXTRAPATHS:append := "${THISDIR}/${BPN}:"

SRC_URI += " \
            file://ampere.cfg \
           "
