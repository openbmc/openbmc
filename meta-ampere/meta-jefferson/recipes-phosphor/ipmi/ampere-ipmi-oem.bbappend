PACKAGECONFIG:append = " mac-address-manual-fru-conf"
PACKAGECONFIG[mac-address-manual-fru-conf] = "-Dmac-address-fru-bus=14 -Dmac-address-fru-addr=80"
