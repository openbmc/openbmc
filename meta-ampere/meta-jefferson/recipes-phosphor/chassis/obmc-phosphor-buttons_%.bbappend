EXTRA_OEMESON:append = " \
                         -Dreset-button-do-warm-reboot=enabled \
                       "
