FILESEXTRAPATHS:append := "${THISDIR}/${BPN}:"
OBMC_CONSOLE_HOST_TTY = "ttyS2"
