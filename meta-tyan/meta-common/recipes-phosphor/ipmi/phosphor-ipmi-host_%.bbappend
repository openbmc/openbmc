PACKAGECONFIG:append = " dynamic-sensors"
