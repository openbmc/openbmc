KCS_DEVICE = "ipmi-kcs1"
