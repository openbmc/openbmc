RDEPENDS_${PN}_remove_fp5280g2 = "p9-vcs-workaround"
