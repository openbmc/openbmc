FILESEXTRAPATHS:prepend:fp5280g2 := "${THISDIR}/${BPN}:"
