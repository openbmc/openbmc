FILESEXTRAPATHS_prepend_fp5280g2 := "${THISDIR}/${BPN}:"
