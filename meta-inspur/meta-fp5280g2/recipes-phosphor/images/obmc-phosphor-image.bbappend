OBMC_IMAGE_EXTRA_INSTALL:append:fp5280g2 = " mboxd liberation-fonts uart-render-controller first-boot-set-mac"
