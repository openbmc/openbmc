PACKAGECONFIG:append:fp5280g2 = " verify_signature"
