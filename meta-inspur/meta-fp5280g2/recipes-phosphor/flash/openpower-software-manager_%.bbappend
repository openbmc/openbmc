PACKAGECONFIG_append_fp5280g2 = " verify_pnor_signature"
