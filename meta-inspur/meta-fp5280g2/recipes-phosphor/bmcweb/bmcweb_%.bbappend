EXTRA_OEMESON:append = " \
    -Dinsecure-tftp-update=enabled \
    "
