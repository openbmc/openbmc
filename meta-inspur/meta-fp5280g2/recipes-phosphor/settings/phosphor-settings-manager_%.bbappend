FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://sol-default.override.yml"
