PHOSPHOR_DBUS_MONITOR_CONFIGS_append_fp5280g2 = " events-policy"
