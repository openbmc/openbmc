MBOXD_FLASH_SIZE:fp5280g2 = "64M"
