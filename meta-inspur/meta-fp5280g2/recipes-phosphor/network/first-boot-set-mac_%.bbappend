SYSTEMD_SERVICE_${PN} += "first-boot-set-mac@eth1.service"
