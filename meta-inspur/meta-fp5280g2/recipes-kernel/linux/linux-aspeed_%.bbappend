FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:fp5280g2 = " file://fp5280g2.cfg"
