FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:nf5280m7 = " file://nf5280m7.cfg"

