RDEPENDS_${PN}-extras_remove = " \
       phosphor-rest \
       phosphor-gevent \
       "
