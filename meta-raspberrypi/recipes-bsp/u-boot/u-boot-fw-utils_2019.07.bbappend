# Apply the same patches for rpi4 as u-boot recipe
require u-boot-rpi4-${PV}.inc
