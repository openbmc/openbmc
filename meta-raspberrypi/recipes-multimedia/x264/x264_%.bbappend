EXTRA_OECONF:append:raspberrypi = " --disable-asm"
EXTRA_OECONF:append:raspberrypi0-wifi = " --disable-asm"
