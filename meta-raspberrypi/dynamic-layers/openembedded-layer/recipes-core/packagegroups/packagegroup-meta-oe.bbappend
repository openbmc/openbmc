RDEPENDS:packagegroup-meta-oe-kernel:remove:rpi = "bpftool"
