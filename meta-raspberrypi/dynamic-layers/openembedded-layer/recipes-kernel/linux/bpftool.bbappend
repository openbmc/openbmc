# remove it when we upgrade to kernel > 4.14
#
COMPATIBLE_HOST_rpi = "null"
