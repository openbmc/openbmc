LINUX_VERSION ?= "4.19.71"
LINUX_RPI_BRANCH ?= "rpi-4.19.y-rt"

SRCREV = "1532ea50263c8fd70f769b55e60fbc6a0c5778a0"

require linux-raspberrypi_4.19.inc
