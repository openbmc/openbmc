RDEPENDS_${PN}_append_df-openpower = " \
    pflash \
    gard \
    fsidbg \
    "
