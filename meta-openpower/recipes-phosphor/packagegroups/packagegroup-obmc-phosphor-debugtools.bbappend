RDEPENDS:${PN}:append:df-openpower = " \
    pflash \
    gard \
    fsidbg \
    "
