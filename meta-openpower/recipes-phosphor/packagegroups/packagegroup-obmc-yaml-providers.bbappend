OBMC_YAML_PROVIDER_RECIPES += " \
    openpower-debug-collector-yaml-provider \
    openpower-ipmi-oem-yaml-provider \
    openpower-occ-control-yaml-provider \
    "
