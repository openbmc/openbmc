RDEPENDS_${PN}_append_df-openpower = " \
        nativesdk-openpower-dbus-interfaces-yaml \
        nativesdk-openpower-debug-collector-yaml \
        "
