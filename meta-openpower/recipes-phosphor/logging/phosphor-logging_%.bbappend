phosphor-logging.bbappend