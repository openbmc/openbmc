RDEPENDS:${PN}:append:df-openpower = " cf-fsi-firmware"
