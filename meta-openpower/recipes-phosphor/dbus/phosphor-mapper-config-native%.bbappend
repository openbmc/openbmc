PHOSPHOR_MAPPER_CONFIGS:append:df-openpower = " openpower-dbus-interfaces-mapper-config-native"
