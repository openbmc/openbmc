EXTRA_OECONF += " --enable-openpower-dbus-interfaces"
