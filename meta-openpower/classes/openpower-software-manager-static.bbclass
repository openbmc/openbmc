RDEPENDS:${PN} += "pflash"

SYSTEMD_SERVICE:${PN} += "openpower-pnor-update@.service"

