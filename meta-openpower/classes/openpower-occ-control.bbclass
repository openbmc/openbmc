YAML_DEST="${D}${datadir}/openpower-occ-control"
