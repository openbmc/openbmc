EXTRA_OEMESON:append = "\
    -Dredfish-dump-log=enabled \
"
