# These machines cannot run in product as they are virtual
# platforms, so allow ssh-pregen-hostkeys to be used.

COMPATIBLE_MACHINE:fvp = "fvp"
