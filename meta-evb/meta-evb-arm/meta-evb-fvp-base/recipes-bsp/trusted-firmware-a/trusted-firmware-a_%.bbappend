COMPATIBLE_MACHINE = "fvp"
TFA_TARGET_PLATFORM = "fvp"
TFA_PLATFORM_IS_FVP = "TRUE"
TFA_PLATFORM = "fvp"
TFA_UBOOT = "1"
TFA_BUILD_TARGET = "bl1 bl2 bl31 dtbs fip"
