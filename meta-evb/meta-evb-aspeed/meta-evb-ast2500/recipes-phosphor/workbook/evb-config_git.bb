SUMMARY = "EVB-AST2500 board wiring"
DESCRIPTION = "Board wiring information for the EVB-AST2500 OpenPOWER system."
PR = "r1"
PV = "1.0+git${SRCPV}"

inherit config-in-skeleton
