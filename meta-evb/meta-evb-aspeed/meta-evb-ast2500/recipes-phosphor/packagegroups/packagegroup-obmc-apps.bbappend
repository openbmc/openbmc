RDEPENDS_${PN}-inventory += " phosphor-cooling-type id-button"
RDEPENDS_${PN}-extras += " phosphor-webui"
