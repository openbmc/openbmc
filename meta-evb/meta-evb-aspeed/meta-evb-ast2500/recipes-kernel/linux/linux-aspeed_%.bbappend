FILESEXTRAPATHS:prepend:evb-ast2500 := "${THISDIR}/${BPN}:"
SRC_URI:append:evb-ast2500 = " file://evb-ast2500.cfg"
