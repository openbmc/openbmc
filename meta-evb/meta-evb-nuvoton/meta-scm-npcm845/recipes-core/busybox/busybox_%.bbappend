FILESEXTRAPATHS:prepend:scm-npcm845 := "${THISDIR}/${PN}:"
SRC_URI:append:scm-npcm845 = " file://busybox.cfg"
