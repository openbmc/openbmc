SNOOP_DEVICE = "npcm7xx-lpc-bpc0"
