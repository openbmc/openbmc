EXTRA_OEMESON:append:scm-npcm845 = " -Derror_info_cap=256"
