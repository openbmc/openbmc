EXTRA_OEMESON:append:evb-npcm845 = " -Derror_info_cap=256"
