FILESEXTRAPATHS:prepend:buv-runbmc := "${THISDIR}/${PN}:"

#SRC_URI:append:buv-runbmc = " file://0001-intrusionsensor-Add-polling-event-status-by-sysfs.patch"
