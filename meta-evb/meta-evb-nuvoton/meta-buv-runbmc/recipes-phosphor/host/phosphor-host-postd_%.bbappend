SNOOP_DEVICE:buv-runbmc = "npcm7xx-lpc-bpc0"
PACKAGECONFIG:buv-runbmc = "7seg"
