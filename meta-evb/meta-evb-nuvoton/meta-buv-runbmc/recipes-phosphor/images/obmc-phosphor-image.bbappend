inherit buv-image
