PACKAGECONFIG:append:buv-runbmc = " log-threshold log-alarm log-pulse log-watchdog"
