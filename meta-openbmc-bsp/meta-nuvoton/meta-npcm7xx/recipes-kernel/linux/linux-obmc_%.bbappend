FILESEXTRAPATHS_prepend_npcm7xx := "${THISDIR}/${PN}:"
SRC_URI_append_npcm7xx = " file://defconfig"
