KBRANCH ?= "dev-4.17"
LINUX_VERSION ?= "4.17.4"

SRCREV="8fb9a0714f8ff91756a9746707c4f884b3745a40"

require linux-nuvoton.inc
