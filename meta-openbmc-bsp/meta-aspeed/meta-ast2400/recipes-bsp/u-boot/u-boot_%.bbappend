FILESEXTRAPATHS_prepend_ast2400 := "${THISDIR}/files:"

SRC_URI_append_ast2400 = " file://fw_env.config"
SRC_URI_append_ast2400 += "file://alt_fw_env.config"
