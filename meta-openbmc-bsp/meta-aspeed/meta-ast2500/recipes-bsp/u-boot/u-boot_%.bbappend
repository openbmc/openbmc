FILESEXTRAPATHS_prepend_ast2500 := "${THISDIR}/files:"

SRC_URI_append_ast2500 = " file://fw_env.config"
SRC_URI_append_ast2500 += "file://alt_fw_env.config"
