KBRANCH ?= "dev-4.17"
LINUX_VERSION ?= "4.17.7"

SRCREV="032f013a2041f7d3e0d604dfd78b8878a69d481d"

require linux-aspeed.inc
