require recipes-bsp/u-boot/u-boot.inc
require u-boot-common.inc

DEPENDS += "dtc-native"
