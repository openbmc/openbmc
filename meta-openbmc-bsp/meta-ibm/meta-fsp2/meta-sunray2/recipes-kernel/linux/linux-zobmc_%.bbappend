FILESEXTRAPATHS_prepend_sunray2 := "${THISDIR}/${PN}:"
SRC_URI_append_sunray2 = " file://defconfig"
