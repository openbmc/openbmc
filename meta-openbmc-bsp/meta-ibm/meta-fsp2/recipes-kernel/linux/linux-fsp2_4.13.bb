LINUX_VERSION ?= "4.13.16"

SRCREV="61dd33b93ddde2f996d087c1129e4309c97822a2"

require linux-fsp2.inc
