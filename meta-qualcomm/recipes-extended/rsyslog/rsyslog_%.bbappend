PACKAGECONFIG:append:qcom-bmc-ast2600 = " imjournal"
