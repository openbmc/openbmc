RDEPENDS:${PN}-extras:append:qcom-bmc-ast2600 = " \
    gdbserver \
    iperf3 \
"
