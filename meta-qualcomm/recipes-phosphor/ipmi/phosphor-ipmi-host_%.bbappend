PACKAGECONFIG:append:qcom-bmc-ast2600 = "\
    dynamic-storages-only \
    dynamic-sensors \
"
