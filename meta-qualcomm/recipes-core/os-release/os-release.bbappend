QUALCOMM_BUILD_NO ??= "local"
VERSION_ID:prepend = "qcom-${QUALCOMM_BUILD_NO}-"
