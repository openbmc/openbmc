u-boot-aspeed-sdk_%.bbappend