FILESEXTRAPATHS_prepend_centriq2400-rep := "${THISDIR}/${PN}:"
OBMC_CONSOLE_HOST_TTY = "ttyS2"
