FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

OBMC_CONSOLE_HOST_TTY = "ttyS3"
