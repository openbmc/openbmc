# e3c246d4i doesn't have the space for the both zstd and xz compression
PACKAGECONFIG:remove:e3c246d4i = " \
    http-zstd \
"
