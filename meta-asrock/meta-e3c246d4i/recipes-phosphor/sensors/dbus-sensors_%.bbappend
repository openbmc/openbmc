PACKAGECONFIG:remove = " \
    exitairtempsensor \
    external \
    intrusionsensor \
    ipmbsensor \
    mctpreactor \
    mcutempsensor \
    nvmesensor \
"
