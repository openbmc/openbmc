FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI:append:x570d4u = " \
    file://x570d4u.cfg \
"
