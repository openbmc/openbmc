DEPENDS:remove = "cracklib"
EXTRA_OECONF:append = " --disable-cracklib-check"
