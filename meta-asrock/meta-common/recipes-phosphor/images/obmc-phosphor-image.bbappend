PACKAGE_INSTALL:remove = "cracklib"
PACKAGE_EXCLUDE:append = "cracklib"
