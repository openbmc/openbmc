PACKAGECONFIG:remove = " mappertool"

