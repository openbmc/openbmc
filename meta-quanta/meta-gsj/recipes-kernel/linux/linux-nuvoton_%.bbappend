FILESEXTRAPATHS_prepend := "${THISDIR}/linux-nuvoton:"
SRC_URI += "file://gsj.cfg"
