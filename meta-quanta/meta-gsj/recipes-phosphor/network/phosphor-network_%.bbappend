EXTRA_OECONF_gsj += " --disable-link-local-autoconfiguration"
