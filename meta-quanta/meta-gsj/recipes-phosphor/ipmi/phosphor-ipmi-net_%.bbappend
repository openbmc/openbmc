# In gsj, usb0 is the interface.
RMCPP_IFACE:gsj = "usb0"

