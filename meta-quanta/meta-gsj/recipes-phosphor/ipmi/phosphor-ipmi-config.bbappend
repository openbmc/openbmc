FILESEXTRAPATHS:prepend:gsj := "${THISDIR}/${PN}:"
