PACKAGECONFIG:append:gsj = " net-bridge reboot-update static-bmc"
