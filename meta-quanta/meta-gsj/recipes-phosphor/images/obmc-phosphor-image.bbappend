OBMC_IMAGE_EXTRA_INSTALL_append_gsj = " phosphor-ipmi-flash"
