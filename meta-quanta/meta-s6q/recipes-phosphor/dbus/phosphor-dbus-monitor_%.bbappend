FILESEXTRAPATHS:append:s6q := ":${THISDIR}/${BPN}"
