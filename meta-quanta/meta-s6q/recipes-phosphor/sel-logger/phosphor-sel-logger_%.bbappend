PACKAGECONFIG:append:s6q = " log-threshold log-watchdog"
