OBMC_IMAGE_EXTRA_INSTALL:append:s6q = " usb-ethernet-gadget"
IMAGE_FEATURES:append:s6q = " obmc-dbus-monitor"
