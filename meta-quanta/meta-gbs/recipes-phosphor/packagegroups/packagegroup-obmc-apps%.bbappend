RDEPENDS_${PN}-fru-ipmi_remove_gbs = "fru-device"
RDEPENDS_${PN}-ikvm_remove_gbs = "obmc-ikvm"
