EXTRA_OECONF_append_gbs = " ERROR_INFO_CAP=256"
