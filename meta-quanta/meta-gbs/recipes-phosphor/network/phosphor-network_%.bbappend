PACKAGECONFIG_append_gbs = " nic-ethtool"
PACKAGECONFIG_remove_gbs = "uboot-env"
