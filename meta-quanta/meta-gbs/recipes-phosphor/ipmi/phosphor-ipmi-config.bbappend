FILESEXTRAPATHS:prepend:gbs := "${THISDIR}/${BPN}:"
