NUVOTON_FLASH_PCIMBOX = "0xF0848000"

PACKAGECONFIG_append_gbs = " nuvoton-p2a-mbox"

IPMI_FLASH_BMC_ADDRESS_gbs = "${NUVOTON_FLASH_PCIMBOX}"
