SNOOP_DEVICE:gbs = "npcm7xx-lpc-bpc0"
PACKAGECONFIG:append:gbs = " 7seg"
