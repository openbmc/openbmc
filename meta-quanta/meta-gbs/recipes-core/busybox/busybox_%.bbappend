FILESEXTRAPATHS:prepend:gbs := "${THISDIR}/${BPN}:"
SRC_URI:append:gbs = " file://busybox.cfg"
