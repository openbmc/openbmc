FILESEXTRAPATHS:prepend:olympus-nuvoton := "${THISDIR}/files:"

#SRC_URI:append:olympus-nuvoton = " \
#    file://0001-networkd-create-new-socket.patch \
#"
