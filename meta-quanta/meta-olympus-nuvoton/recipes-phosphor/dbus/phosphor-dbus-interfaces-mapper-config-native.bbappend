PHOSPHOR_MAPPER_SERVICE:append:olympus-nuvoton = " com.intel.crashdump"
PHOSPHOR_MAPPER_INTERFACE:append:olympus-nuvoton = " com.intel.crashdump"
