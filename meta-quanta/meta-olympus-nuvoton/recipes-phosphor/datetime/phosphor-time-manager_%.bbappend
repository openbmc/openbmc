FILESEXTRAPATHS:prepend:olympus-nuvoton := "${THISDIR}/${PN}:"

#SRC_URI:append:olympus-nuvoton = " file://0001-Modify-dbus-call-style-for-calling-setTime.patch"

