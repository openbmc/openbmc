FILESEXTRAPATHS:prepend:olympus-nuvoton := "${THISDIR}/${PN}:"

SRCREV = "e32e33784a1883ee4528b17617df14f3114b0f5e"
