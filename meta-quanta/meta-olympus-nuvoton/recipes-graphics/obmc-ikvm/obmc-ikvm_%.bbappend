LIC_FILES_CHKSUM:olympus-nuvoton = "file://LICENSE;md5=75859989545e37968a99b631ef42722e"
SRC_URI:nuvoton:olympus-nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm.git;branch=upstream-v4l2;protocol=https"
SRCREV:nuvoton:olympus-nuvoton := "d3def78fbab34941ef572cce8fa66a5525d5126c"
