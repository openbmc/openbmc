FILESEXTRAPATHS:prepend:olympus-nuvoton := "${THISDIR}/${PN}:"
