UBOOT_MAKE_TARGET:append:olympus-nuvoton = " DEVICE_TREE=${UBOOT_DEVICETREE}"

