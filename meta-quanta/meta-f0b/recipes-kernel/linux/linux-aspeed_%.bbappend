FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += " file://f0b.cfg"
