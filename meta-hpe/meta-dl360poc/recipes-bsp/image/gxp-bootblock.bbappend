inherit gxp-bootblock-n-poc
