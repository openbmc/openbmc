FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://faillock.conf \
            "
