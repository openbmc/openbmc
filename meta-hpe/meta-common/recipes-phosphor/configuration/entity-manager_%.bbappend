PACKAGECONFIG:append = " dts-vpd"
