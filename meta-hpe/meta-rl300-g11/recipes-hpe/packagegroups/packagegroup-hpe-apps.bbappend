RDEPENDS:${PN}-system += "ampere-platform-mgmt"
