inherit gxp2-bootblock-n
