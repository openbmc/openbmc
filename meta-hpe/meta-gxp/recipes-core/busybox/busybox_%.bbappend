SRC_URI += "file://FEATURE_FANCY_HEAD.cfg"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
