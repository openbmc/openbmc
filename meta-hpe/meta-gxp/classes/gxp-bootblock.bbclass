LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

addtask deploy before do_build after do_compile

