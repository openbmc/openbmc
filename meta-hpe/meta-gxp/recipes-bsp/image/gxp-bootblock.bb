inherit gxp-bootblock
