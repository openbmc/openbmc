FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed:"
SRC_URI:append:aspeed-g6 = " file://rainiera6.cfg"

