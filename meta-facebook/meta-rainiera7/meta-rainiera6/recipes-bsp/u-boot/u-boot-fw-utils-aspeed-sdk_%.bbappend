FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-aspeed-sdk:"
SRC_URI:append:aspeed-g6 = " file://rainiera6.cfg"
