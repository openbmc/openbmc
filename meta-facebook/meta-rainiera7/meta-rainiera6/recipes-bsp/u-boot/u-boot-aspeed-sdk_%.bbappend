FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI:append:aspeed-g6 = " file://rainiera6.cfg"
