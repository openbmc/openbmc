FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

