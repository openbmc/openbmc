FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"