FILESEXTRAPATHS:append := ":${THISDIR}/${BPN}"
SOURCE_FILES:append = " 998-rtc-detection"