PHOSPHOR_DBUS_MONITOR_CONFIGS:append = " fan-policy"
PHOSPHOR_DBUS_MONITOR_CONFIGS:append = " thermal-policy"