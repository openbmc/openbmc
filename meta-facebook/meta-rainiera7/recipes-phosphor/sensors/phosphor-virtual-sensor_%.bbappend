FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"