EXTRA_OEMESON:remove = "-Dmachine='${MACHINE}'"
EXTRA_OEMESON:append = " -Dmachine='yosemite5'"
