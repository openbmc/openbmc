PACKAGECONFIG:append = " \
    smbios-ipmi-blob \
    tpm-dbus \
    firmware-inventory-dbus \
"
