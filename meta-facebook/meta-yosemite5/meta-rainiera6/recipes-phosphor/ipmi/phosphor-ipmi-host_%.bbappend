#remove xyz.openbmc_project.Ipmi.Internal.SoftPowerOff.service
SOFT_SVC = ""
SOFT_TGTFMT = ""
SOFT_FMT = ""

OBMC_ORG_IPMI_OEM_PROVIDERS = "arm"
