IPMB_CHANNELS:yosemite5 = "\
    /dev/ipmb-7 \
    "

IPMB_REMOTE_ADDR:yosemite5 = "\
    96 \
    "
