FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI:append:aspeed-g6 = " file://yosemite5.cfg"
