FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-aspeed-sdk:"
SRC_URI:append:aspeed-g6 = " file://yosemite5.cfg"
