IPMB_CHANNELS:minerva = "\
    /dev/ipmb-14 \
    "
IPMB_REMOTE_ADDR:minerva = "\
    96 \
    "
