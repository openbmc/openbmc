FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI +="file://fby35.cfg"
