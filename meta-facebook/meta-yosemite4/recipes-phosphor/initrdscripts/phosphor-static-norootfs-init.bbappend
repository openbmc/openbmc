FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"
SOURCE_FILES:append = " 99-platform-init"