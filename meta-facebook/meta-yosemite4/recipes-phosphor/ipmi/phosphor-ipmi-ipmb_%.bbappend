IPMB_CHANNELS:yosemite4 = "\
    /dev/ipmb-13 \
    "

IPMB_REMOTE_ADDR:yosemite4 = "\
    96 \
    "
