FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI +="file://yosemite4.cfg"
