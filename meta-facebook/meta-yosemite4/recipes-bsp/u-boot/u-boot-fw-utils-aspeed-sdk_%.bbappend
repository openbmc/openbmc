FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:${THISDIR}/../../../recipes-bsp/uboot/files:"
SRC_URI += "file://yosemite4-common.cfg"
