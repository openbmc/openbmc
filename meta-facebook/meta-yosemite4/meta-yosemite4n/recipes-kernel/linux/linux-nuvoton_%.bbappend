FILESEXTRAPATHS:prepend := "${THISDIR}/linux-nuvoton:${THISDIR}/../../../../recipes-kernel/linux/files:"
SRC_URI += "file://yosemite4-common.cfg \
            file://yosemite4.cfg \
           "
