FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI +=  "file://lfdarwin.cfg \
            "
