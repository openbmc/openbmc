# greatlakes doesn't use xyz.openbmc_project.Ipmi.Internal.SoftPowerOff.service in power control
SOFT_SVC = ""
SOFT_TGTFMT = ""
SOFT_FMT = ""

