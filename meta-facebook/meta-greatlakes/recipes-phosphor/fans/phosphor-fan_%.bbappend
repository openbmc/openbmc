EXTRA_OEMESON:greatlakes = "-Duse-host-power-state=enabled -Dsensor-monitor-hard-shutdown-delay=0"
