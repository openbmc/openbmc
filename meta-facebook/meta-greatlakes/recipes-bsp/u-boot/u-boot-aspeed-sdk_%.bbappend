FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI +="file://greatlakes.cfg"
