CPU_CRIT_TGT = ""
