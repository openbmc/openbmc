FILESEXTRAPATHS:prepend := "${THISDIR}/phosphor-host-postd:"

S = "${WORKDIR}/git"

SNOOP_DEVICE = "aspeed-lpc-pcc"
POST_CODE_BYTES = "8"
