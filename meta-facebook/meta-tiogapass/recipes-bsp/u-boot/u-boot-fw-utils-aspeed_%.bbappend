FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-aspeed:"
SRC_URI += "file://0001-configs-ast-common-use-57600-baud-rate-to-match-Tiog.patch"
