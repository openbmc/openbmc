ADDITIONAL_CONSOLE_IDS = "\
    ath_uart0 \
    ath_uart1 \
    ath_uart_ccp0 \
    ath_uart_ccp1 \
    nowl_uart \
    sowl_uart \
    mmc_uart \
"
