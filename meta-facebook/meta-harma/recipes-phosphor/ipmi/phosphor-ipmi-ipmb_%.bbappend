IPMB_CHANNELS:harma = "\
    /dev/ipmb-14 \
    "
IPMB_REMOTE_ADDR:harma = "\
    96 \
    "
