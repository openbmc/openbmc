FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI +="file://harma.cfg"
