NCSI_ETH_INTF = "eth0 eth1"
