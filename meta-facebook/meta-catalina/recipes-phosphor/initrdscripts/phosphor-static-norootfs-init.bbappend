FILESEXTRAPATHS:append := ":${THISDIR}/${BPN}"
SOURCE_FILES:append = " 999-platform-init"