CXXFLAGS:append = " -DMONITOR_USE_HOST_STATE"
