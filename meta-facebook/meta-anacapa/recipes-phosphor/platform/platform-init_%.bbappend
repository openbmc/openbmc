EXTRA_OEMESON:append = " -Dplatform-name=meta-anacapa"
