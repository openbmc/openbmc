# We need the anacapa override here because there is already a machine-type
# override.  If we don't set the override then the machine-type one takes
# precedent.
OBMC_CONSOLE_HOST_TTY:anacapa = "ttyS0"
