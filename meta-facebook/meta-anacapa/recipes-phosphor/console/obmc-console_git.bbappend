OBMC_CONSOLE_HOST_TTY = "ttyS0"
