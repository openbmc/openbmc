IPMB_CHANNELS = "\
    /dev/ipmb-1 \
    /dev/ipmb-3 \
    /dev/ipmb-5 \
    /dev/ipmb-7 \
    /dev/ipmb-13 \
    "
