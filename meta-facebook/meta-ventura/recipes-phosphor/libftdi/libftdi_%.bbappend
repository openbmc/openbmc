PACKAGECONFIG = "ftdi-eeprom"
