require common/images/fb-openbmc-image.inc
