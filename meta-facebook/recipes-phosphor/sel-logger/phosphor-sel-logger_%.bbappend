PACKAGECONFIG:append = " log-pulse log-watchdog send-to-logger"
