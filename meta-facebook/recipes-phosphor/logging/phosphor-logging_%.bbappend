EXTRA_OEMESON:append = " -Derror_cap=1000"
EXTRA_OEMESON:append = " -Derror_info_cap=1000"