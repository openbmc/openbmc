EXTRA_OEMESON:append = " \
    -Dmax-reading-parameters=1200 \
"
