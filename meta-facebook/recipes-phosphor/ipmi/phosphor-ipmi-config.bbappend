FILESEXTRAPATHS_prepend_tiogapass := "${THISDIR}/${PN}:"
