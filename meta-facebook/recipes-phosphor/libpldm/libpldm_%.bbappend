LIBPLDM_OEM := "meta"
PACKAGECONFIG:append = " oem"
