FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-aspeed-sdk:"

SRC_URI += " \
            file://0001-u-boot-ast2600-57600-baudrate-for-bletchley.patch \
           "
