FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI +="file://bletchley.cfg"
