CFLAGS += " -D_FILE_OFFSET_BITS=64"
