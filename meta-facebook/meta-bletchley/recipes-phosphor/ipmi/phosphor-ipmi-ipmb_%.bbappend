IPMB_CHANNELS = "/dev/ipmb-13"
