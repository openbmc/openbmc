FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI:append:aspeed-g6 = " file://ventura2.cfg"
