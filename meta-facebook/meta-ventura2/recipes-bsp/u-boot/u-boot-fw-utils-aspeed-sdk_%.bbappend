FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-aspeed-sdk:"
SRC_URI:append:aspeed-g6 = " file://ventura2.cfg"
