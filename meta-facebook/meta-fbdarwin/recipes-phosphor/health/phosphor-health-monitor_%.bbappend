# Disable reboot.target for critical CPU thresholds to avoid rebooting
# when the BMC is busy or under load.
CPU_CRIT_TGT = ""
