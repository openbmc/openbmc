FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI +=  "file://fbdarwin.cfg \
            "
