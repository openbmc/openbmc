FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

DEFAULT_TIMEZONE = "PST8PDT"
