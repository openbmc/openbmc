RDEPENDS:${PN}-leds:remove = "phosphor-led-manager-faultmonitor"
RDEPENDS:${PN}-leds:remove = "phosphor-led-manager"
RDEPENDS:${PN}-extras += "curl"
RDEPENDS:${PN}-extras:append:evk-axiado-github = " eipdrv-axiado shimfwl-axiado"
