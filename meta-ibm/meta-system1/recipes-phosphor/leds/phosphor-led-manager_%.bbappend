FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"

SRC_URI:append = " file://bmc_booted.conf "
