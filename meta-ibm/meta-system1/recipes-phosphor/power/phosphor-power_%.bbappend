# System1 requires 30s for FPGA poweron
EXTRA_OEMESON:append = " -Dpgood-timeout-value=30"
