EXTRA_OEMESON:append:p10bmc = " -Dpower-button-profile=host_then_chassis_poweroff"
