PACKAGECONFIG:ibm-enterprise = " \
    persist-settings-to-file \
"
