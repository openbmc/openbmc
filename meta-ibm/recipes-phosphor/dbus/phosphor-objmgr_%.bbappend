PACKAGECONFIG:append = " unit-failure-monitor"

