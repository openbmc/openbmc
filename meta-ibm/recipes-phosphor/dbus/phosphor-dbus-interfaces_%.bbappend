OBMC_ORG_YAML_SUBDIRS_append_witherspoon = " com/ibm"
OBMC_ORG_YAML_SUBDIRS_append_p10bmc = " com/ibm"
