PHOSPHOR_MAPPER_CONFIGS:append = " ibm-dbus-interfaces-mapper-config-native"
