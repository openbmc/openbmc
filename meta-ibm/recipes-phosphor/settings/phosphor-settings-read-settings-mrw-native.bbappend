FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
MRW_EXPRESSION_VARS = "-v PS_DERATING=${POWER_SUPPLY_DERATING_FACTOR}"
