PACKAGECONFIG:p10bmc = "hwmontempsensor"
PACKAGECONFIG:genesis3 = " \
    hwmontempsensor \
    fansensor \
    psusensor \
    intelcpusensor \
    "
