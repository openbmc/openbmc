EXTRA_OEMESON:append:p10bmc = " -Dhostboot-dump-collection=enabled "
