OBMC_IMAGE_EXTRA_INSTALL_append = "\
    phosphor-nslcd-cert-config \
    phosphor-nslcd-authority-cert-config \
    "
