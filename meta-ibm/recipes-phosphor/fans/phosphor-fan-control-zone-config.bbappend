FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
