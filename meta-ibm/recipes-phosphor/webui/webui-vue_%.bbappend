FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

EXTRA_OENPM:witherspoon-tacoma = "-- --mode ibm"
EXTRA_OENPM:p10bmc = "-- --mode ibm"
