PACKAGECONFIG_append_p10bmc = " ibm-hypervisor-cert"
PACKAGECONFIG_append_witherspoon-tacoma = " ibm-hypervisor-cert"
