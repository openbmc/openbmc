FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
