PACKAGECONFIG:append:ibm-ac-server = " verify_pnor_signature"
PACKAGECONFIG:append:mihawk = " verify_pnor_signature"
