RDEPENDS_${PN}_append_romulus = " avsbus-control"
RDEPENDS_${PN}_append_romulus = " vrm-control"
RDEPENDS_${PN}_remove_romulus = "p9-vcs-workaround"
