RDEPENDS:${PN}-inventory:append:romulus = " id-button"
RDEPENDS:${PN}-extras:append:romulus = " phosphor-image-signing"
RDEPENDS:${PN}-devtools:remove:romulus = " ffdc lrzsz rsync"
