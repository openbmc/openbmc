# Running out of room on romulus, remove croserver
RDEPENDS:${PN}-system:remove = " croserver"
