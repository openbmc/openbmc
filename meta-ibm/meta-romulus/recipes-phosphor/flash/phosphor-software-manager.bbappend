PACKAGECONFIG_append = " verify_signature"
