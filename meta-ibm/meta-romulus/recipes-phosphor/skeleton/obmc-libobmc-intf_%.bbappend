obmc-libobmc-intf.bbappend