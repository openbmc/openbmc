FILESEXTRAPATHS:prepend:romulus := "${THISDIR}/${BPN}:"
SRC_URI:append:romulus = " file://romulus.cfg"
