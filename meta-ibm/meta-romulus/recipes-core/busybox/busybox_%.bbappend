SRC_URI += "file://small-flash.cfg"
