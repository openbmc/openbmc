EXTRA_OEMESON:append:ibm-enterprise = " -Dhostboot-dump-collection=enabled "
