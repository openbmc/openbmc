RDEPENDS:${PN}:append:ibm-ac-server = " avsbus-control"
RDEPENDS:${PN}:append:ibm-ac-server = " power-workarounds"
