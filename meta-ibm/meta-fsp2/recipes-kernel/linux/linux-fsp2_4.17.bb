LINUX_VERSION ?= "4.17.18"

SRCREV="80d901318acc389e6e09698a8927bf6eb29da314"

require linux-fsp2.inc
