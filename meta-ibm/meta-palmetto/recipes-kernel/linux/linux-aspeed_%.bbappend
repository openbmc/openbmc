FILESEXTRAPATHS:prepend:palmetto := "${THISDIR}/${BPN}:"
SRC_URI += "file://palmetto.cfg"
