OBMC_IMAGE_EXTRA_INSTALL_append = " aspeed-lpc-ctrl"
