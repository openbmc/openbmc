FILESEXTRAPATHS:prepend:palmetto := "${THISDIR}/${BPN}:"
SRC_URI:append:palmetto = " file://palmetto.xml.patch.xml"
