FILESEXTRAPATHS_prepend_palmetto := "${THISDIR}/${PN}:"
