DEPENDS:append = " inventory-cleanup"
