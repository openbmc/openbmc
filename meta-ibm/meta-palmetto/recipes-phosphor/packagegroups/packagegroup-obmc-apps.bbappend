RDEPENDS:${PN}-inventory:append:palmetto = " openpower-occ-control"
