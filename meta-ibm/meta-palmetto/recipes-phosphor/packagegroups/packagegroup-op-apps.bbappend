RDEPENDS_${PN}-chassis_remove += "obmc-button-reset"
RDEPENDS_${PN}-fans_remove += "obmc-control-fan"
