FILESEXTRAPATHS:prepend:palmetto := "${THISDIR}/${BPN}:"
