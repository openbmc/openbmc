EXTRA_OEMESON:append = " -Dmax-cpus=4 -Dwith-host-communication-protocol= -Dpower10-support=disabled -Dread-occ-sensors=disabled"
