FILESEXTRAPATHS:append := ":${THISDIR}/${BPN}"

SRC_URI:append = " file://bmc_booted.conf "