DEPENDS:append = " static-inventory"
