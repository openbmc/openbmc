SUMMARY = "Witherspoon board wiring"
DESCRIPTION = "Board wiring information for the Witherspoon OpenPOWER system."
PR = "r1"
PV = "1.0+git${SRCPV}"

inherit config-in-skeleton
