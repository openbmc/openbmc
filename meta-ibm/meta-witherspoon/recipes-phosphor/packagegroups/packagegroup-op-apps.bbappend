RDEPENDS_${PN}-fans_remove += "obmc-control-fan"
