PACKAGECONFIG_append_witherspoon-128 = " openpower-pels"
PACKAGECONFIG_append_rainier = " openpower-pels"
