RDEPENDS_${PN}_append_witherspoon = " avsbus-control"
RDEPENDS_${PN}_append_witherspoon = " vrm-control"
RDEPENDS_${PN}_append = " power-workarounds"
RDEPENDS_${PN}_remove += "p9-vcs-workaround"
