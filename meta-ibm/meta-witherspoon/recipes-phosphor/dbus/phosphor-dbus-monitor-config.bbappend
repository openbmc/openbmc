PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " witherspoon-fan-policy"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " witherspoon-thermal-policy"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " witherspoon-power-supply-policy"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " witherspoon-events-policy"
