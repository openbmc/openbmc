PACKAGECONFIG_append_df-openpower-ubi-fs = " verify_pnor_signature"
