FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/${MACHINE}/"
FILESEXTRAPATHS_prepend_witherspoon-128 := "${THISDIR}/${PN}/witherspoon:"
