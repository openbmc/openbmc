OBMC_IMAGE_EXTRA_INSTALL_append = " mboxd max31785-msl phosphor-msl-verify liberation-fonts uart-render-controller first-boot-set-mac first-boot-set-hostname"
