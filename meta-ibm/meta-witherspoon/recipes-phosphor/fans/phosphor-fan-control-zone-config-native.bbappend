FILESEXTRAPATHS_prepend := "${THISDIR}/${MACHINE}-${PN}:"
