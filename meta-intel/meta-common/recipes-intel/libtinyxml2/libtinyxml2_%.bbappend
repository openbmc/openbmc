# update libtinyxml2 to version 6.0.0
SRCREV = "8c8293ba8969a46947606a93ff0cb5a083aab47a"
FILES_${PN}-dev += "${libdir}/cmake/tinyxml2/*"
