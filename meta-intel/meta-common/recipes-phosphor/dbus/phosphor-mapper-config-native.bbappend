PHOSPHOR_MAPPER_CONFIGS_append = " intel-dbus-interfaces-mapper-config-native"
