SUMMARY = "s2600wf board wiring"
DESCRIPTION = "Board wiring information for the s2600wf system."
PR = "r1"

inherit config-in-skeleton
