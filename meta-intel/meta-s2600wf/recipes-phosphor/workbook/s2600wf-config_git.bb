SUMMARY = "s2600wf board wiring"
DESCRIPTION = "Board wiring information for the s2600wf system."
PR = "r1"
PV = "1.0+git${SRCPV}"

inherit config-in-skeleton
